<module name="ISS_CSI2_A_REGS1" acronym="" XML_version="1.0" HW_revision="n/a" description="">
  <register id="CSI2_REVISION" acronym="CSI2_REVISION" offset="0x0" width="32" description="IP Revision Identifier (X.Y.R) Used by software to track features, bugs, and compatibility">
    <bitfield id="REVISION" width="32" begin="31" end="0" resetval="See" description="IP Revision" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_SYSCONFIG" acronym="CSI2_SYSCONFIG" offset="0x10" width="32" description="SYSTEM CONFIGURATION REGISTER This register is the OCP-socket system configuration register.">
    <bitfield id="RESERVED" width="18" begin="31" end="14" resetval="0x00000" description="" range="" rwaccess="R"/>
    <bitfield id="MSTANDBY_MODE" width="2" begin="13" end="12" resetval="0x0" description="Sets the behavior of the master port power management signals." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="MSTANDBY_MODE_0" description="Force-standby. MStandby is only asserted when the module is disabled."/>
      <bitenum value="1" id="1" token="MSTANDBY_MODE_1" description="No-standby. MStandby is never asserted."/>
      <bitenum value="2" id="2" token="MSTANDBY_MODE_2" description="Smart-standby: MStandby is asserted based on the activity of the module. The module will try to go to standby during the vertical blanking period."/>
    </bitfield>
    <bitfield id="RESERVED" width="10" begin="11" end="2" resetval="0x000" description="" range="" rwaccess="R"/>
    <bitfield id="SOFT_RESET" width="1" begin="1" end="1" resetval="0" description="Software reset. Set the bit to 1 to trigger a module reset. The bit is automatically reset by the hardware. During reads return 0." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="SOFT_RESET_0" description="Normal mode."/>
      <bitenum value="1" id="1" token="SOFT_RESET_1" description="The module is reset Note: Before setting the software reset bit to 1 in register, the user must have access to a CSI2 receiver register."/>
    </bitfield>
    <bitfield id="AUTO_IDLE" width="1" begin="0" end="0" resetval="1" description="Internal OCP gating strategy" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="AUTO_IDLE_0" description="OCP clock is free-running."/>
      <bitenum value="1" id="1" token="AUTO_IDLE_1" description="Automatic OCP clock gating strategy is applied based on the OCP interface activity."/>
    </bitfield>
  </register>
  <register id="CSI2_SYSSTATUS" acronym="CSI2_SYSSTATUS" offset="0x14" width="32" description="SYSTEM STATUS REGISTER This register provides status information about the module, excluding the interrupt status register.">
    <bitfield id="RESERVED" width="31" begin="31" end="1" resetval="0x0000 0000" description="Reads returns 0." range="" rwaccess="R"/>
    <bitfield id="RESET_DONE" width="1" begin="0" end="0" resetval="1" description="Internal reset monitoring" range="" rwaccess="R">
      <bitenum value="1" id="1" token="RESET_DONE_1_r" description="Reset completed."/>
      <bitenum value="0" id="0" token="RESET_DONE_0_r" description="Internal module reset is on going."/>
    </bitfield>
  </register>
  <register id="CSI2_IRQSTATUS" acronym="CSI2_IRQSTATUS" offset="0x18" width="32" description="INTERRUPT STATUS REGISTER - All contexts This register associates one bit for each context in order to determine which context has generated the interrupt. The context shall be enabled for events to be generated on that context. If the context is disabled, the interrupt is not generated.">
    <bitfield id="RESERVED" width="17" begin="31" end="15" resetval="0x00000" description="" range="" rwaccess="R"/>
    <bitfield id="OCP_ERR_IRQ" width="1" begin="14" end="14" resetval="0" description="OCP Error Interrupt" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="OCP_ERR_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="OCP_ERR_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="SHORT_PACKET_IRQ" width="1" begin="13" end="13" resetval="0" description="Short packet reception status (other than synch events: Line Start, Line End, Frame Start, and Frame End: data type between 0x8 and x0F only shall be considered)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="SHORT_PACKET_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="SHORT_PACKET_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="12" end="12" resetval="0" description="ECC has been used to do the correction of the only 1-bit error status (short packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ECC_NO_CORRECTION_IRQ" width="1" begin="11" end="11" resetval="0" description="ECC error status (short and long packets). No correction of the header because of more than 1-bit error." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_NO_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_NO_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="10" end="10" resetval="0" description="Reserved . ." range="" rwaccess="R"/>
    <bitfield id="COMPLEXIO_ERR_IRQ" width="1" begin="9" end="9" resetval="0" description="Error signaling from complex I/O: status of the PHY errors received from the complex I/O (events are defined inCSI2_COMPLEXIO_IRQSTATUS for the complex I/O)." range="" rwaccess="R">
      <bitenum value="1" id="1" token="COMPLEXIO_ERR_IRQ_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="COMPLEXIO_ERR_IRQ_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="FIFO_OVF_IRQ" width="1" begin="8" end="8" resetval="0" description="FIFO overflow error status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FIFO_OVF_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FIFO_OVF_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CONTEXT7" width="1" begin="7" end="7" resetval="0" description="Context 7" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT7_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT7_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT6" width="1" begin="6" end="6" resetval="0" description="Context 6" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT6_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT6_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT5" width="1" begin="5" end="5" resetval="0" description="Context 5" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT5_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT5_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT4" width="1" begin="4" end="4" resetval="0" description="Context 4" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT4_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT4_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT3" width="1" begin="3" end="3" resetval="0" description="Context 3" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT3_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT3_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT2" width="1" begin="2" end="2" resetval="0" description="Context 2" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT2_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT2_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT1" width="1" begin="1" end="1" resetval="0" description="Context 1" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT1_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT1_0_r" description="READS: Event is false."/>
    </bitfield>
    <bitfield id="CONTEXT0" width="1" begin="0" end="0" resetval="0" description="Context 0" range="" rwaccess="R">
      <bitenum value="1" id="1" token="CONTEXT0_1_r" description="READS: Event is true (pending)."/>
      <bitenum value="0" id="0" token="CONTEXT0_0_r" description="READS: Event is false."/>
    </bitfield>
  </register>
  <register id="CSI2_IRQENABLE" acronym="CSI2_IRQENABLE" offset="0x1C" width="32" description="INTERRUPT ENABLE REGISTER - All contexts This register associates one bit for each context in order to enable/disable each context individually.">
    <bitfield id="RESERVED" width="17" begin="31" end="15" resetval="0x00000" description="" range="" rwaccess="R"/>
    <bitfield id="OCP_ERR_IRQ" width="1" begin="14" end="14" resetval="0" description="OCP Error Interrupt" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="OCP_ERR_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="OCP_ERR_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="SHORT_PACKET_IRQ" width="1" begin="13" end="13" resetval="0" description="Short packet reception (other than synch events: Line Start, Line End, Frame Start, and Frame End: data type between 0x8 and x0F only shall be considered)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="SHORT_PACKET_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="SHORT_PACKET_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="12" end="12" resetval="0" description="ECC has been used to correct the only 1-bit error (short packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ECC_NO_CORRECTION_IRQ" width="1" begin="11" end="11" resetval="0" description="ECC error (short and long packets). No correction of the header because of more than 1-bit error." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_NO_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_NO_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="10" end="10" resetval="0" description="Reserved . ." range="" rwaccess="RW"/>
    <bitfield id="COMPLEXIO_ERR_IRQ" width="1" begin="9" end="9" resetval="0" description="Error signaling from complex I/O: the interrupt is triggered when any error is received from the complex I/O (events are defined inCSI2_COMPLEXIO_IRQSTATUS for the complex I/O)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="COMPLEXIO_ERR_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="COMPLEXIO_ERR_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FIFO_OVF_IRQ" width="1" begin="8" end="8" resetval="0" description="FIFO overflow enable" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FIFO_OVF_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FIFO_OVF_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT7" width="1" begin="7" end="7" resetval="0" description="Context 7" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT7_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT7_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT6" width="1" begin="6" end="6" resetval="0" description="Context 6" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT6_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT6_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT5" width="1" begin="5" end="5" resetval="0" description="Context 5" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT4" width="1" begin="4" end="4" resetval="0" description="Context 4" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT3" width="1" begin="3" end="3" resetval="0" description="Context 3" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT2" width="1" begin="2" end="2" resetval="0" description="Context 2" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT1" width="1" begin="1" end="1" resetval="0" description="Context 1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CONTEXT0" width="1" begin="0" end="0" resetval="0" description="Context 0" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CONTEXT0_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CONTEXT0_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTRL" acronym="CSI2_CTRL" offset="0x40" width="32" description="GLOBAL CONTROL REGISTER This register controls the CSI2 RECEIVER module. This register shall not be modified dynamically (except IF_EN bit field).">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="Reserved" range="" rwaccess="R"/>
    <bitfield id="BURST_SIZE_EXPAND" width="1" begin="16" end="16" resetval="0" description="Sets the DMA burst size on the L3 interconnect." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BURST_SIZE_EXPAND_0" description="Use the burst size defined in the BURST_SIZE register"/>
      <bitenum value="1" id="1" token="BURST_SIZE_EXPAND_1" description="Allow generation of 16x64-bit bursts"/>
    </bitfield>
    <bitfield id="VP_CLK_EN" width="1" begin="15" end="15" resetval="0" description="VP clock enable." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_CLK_EN_0" description="The VP clock is disabled."/>
      <bitenum value="1" id="1" token="VP_CLK_EN_1" description="The VP clock is enabled."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="14" end="14" resetval="0" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="NON_POSTED_WRITE" width="1" begin="13" end="13" resetval="0" description="Not posted writes" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="NON_POSTED_WRITE_0" description="Disable"/>
      <bitenum value="1" id="1" token="NON_POSTED_WRITE_1" description="Enable"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="12" end="12" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="VP_ONLY_EN" width="1" begin="11" end="11" resetval="0" description="VP only enable." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_ONLY_EN_0" description="The VP is enabled and the OCP master port is enabled."/>
      <bitenum value="1" id="1" token="VP_ONLY_EN_1" description="The VP is enabled and the OCP master port is disabled."/>
    </bitfield>
    <bitfield id="STREAMING_32_BIT" width="1" begin="10" end="10" resetval="0" description="Indicates if 64-bit or 32-bit streaming burst is used. Valid only if CSI2_CTRL.STREAMING=1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STREAMING_32_BIT_0" description="64-bit streaming burst is used; byte enable pattern is 0xFF"/>
      <bitenum value="1" id="1" token="STREAMING_32_BIT_1" description="32-bit streaming burst is used; byte enable pattern is 0x0F"/>
    </bitfield>
    <bitfield id="VP_OUT_CTRL" width="2" begin="9" end="8" resetval="0x0" description="VP_PCLK control. Sets the VP_PCLK as a function of the ISS interconnect interface clock (OCPCLK)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_OUT_CTRL_0" description="No division: VP_PCLK = OCPCLK."/>
      <bitenum value="1" id="1" token="VP_OUT_CTRL_1" description="Division by 2: VP_PCLK = OCPCLK / 2."/>
      <bitenum value="3" id="3" token="VP_OUT_CTRL_3" description="Division by 4: VP_PCLK = OCPCLK / 4."/>
      <bitenum value="2" id="2" token="VP_OUT_CTRL_2" description="Division by 3: VP_PCLK = OCPCLK / 3. Example scenarios: - Low VP_PCLK, Memory -&amp;gt; VP: Same as typical memory -&amp;gt; VP, but VP_PCLK = OCPCLK/2 - Typical sensor -&amp;gt; VP: Autoidle enabled, FCLK at optimal rate, sensor provides DPCM compressed RAW12 data at 650 Mbps. Image timings VP_PCLK = (OCPCLK/2) and [31:15] FRACDIV = 0xD000 2600 active pixels/line, 128 blanking pixels, no vertical blanking. (This scenario corresponds to the OTF operation at maximum CCP2 speed.)"/>
    </bitfield>
    <bitfield id="DBG_EN" width="1" begin="7" end="7" resetval="0" description="Enables the debug mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DBG_EN_0" description="Disable"/>
      <bitenum value="1" id="1" token="DBG_EN_1" description="Enable"/>
    </bitfield>
    <bitfield id="BURST_SIZE" width="2" begin="6" end="5" resetval="0x0" description="Sets the DMA burst size on the L3 interconnect." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BURST_SIZE_0" description="1x64 OCP writes"/>
      <bitenum value="1" id="1" token="BURST_SIZE_1" description="2x64 OCP writes"/>
      <bitenum value="3" id="3" token="BURST_SIZE_3" description="8x64 OCP writes"/>
      <bitenum value="2" id="2" token="BURST_SIZE_2" description="4x64 OCP writes"/>
    </bitfield>
    <bitfield id="ENDIANNESS" width="1" begin="4" end="4" resetval="0" description="Select endianness for YUV4:2:2 8 bit and YUV4:2:0 legacy formats." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ENDIANNESS_0" description="Use native MIPI CSI2 endianness: Little endian for all formats except for YUV4:2:2 8b and YUV4:2:0 Legacy which a big endian."/>
      <bitenum value="1" id="1" token="ENDIANNESS_1" description="Store all pixel formats little endian."/>
    </bitfield>
    <bitfield id="FRAME" width="1" begin="3" end="3" resetval="0" description="Set the modality in which IF_EN works." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_0" description="If IF_EN = 0 the interface is disabled immediately."/>
      <bitenum value="1" id="1" token="FRAME_1" description="If IF_EN = 1 the interface is disabled after all FEC sync code have been received for the active contexts."/>
    </bitfield>
    <bitfield id="ECC_EN" width="1" begin="2" end="2" resetval="0" description="Enables the Error Correction Code check for the received header (short and long packets for all virtual channel ids)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="ECC_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="1" end="1" resetval="0" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="IF_EN" width="1" begin="0" end="0" resetval="0" description="Enables the physical interface to the module." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="IF_EN_0" description="The interface is disabled. If FRAME = 0, it is disabled immediately. If FRAME = 1, it is disabled when each context has received the FEC sync code."/>
      <bitenum value="1" id="1" token="IF_EN_1" description="The interface is enabled immediately, the data acquisition starts on the next FSC sync code. Writing 1 to this register when the current value is 0 has the effect to clear the output FIFO. The pixel data of the following frame will be written in the PING buffer, that is, the CSI2_CTX_CTRL.PING_PONG bits are reset to 0 as well."/>
    </bitfield>
  </register>
  <register id="CSI2_DBG_H" acronym="CSI2_DBG_H" offset="0x44" width="32" description="DEBUG REGISTER (Header) This register provides a way to debug the CSI2 RECEIVER module with no image sensor connected to the module. The debug mode is enabled by .DBG_EN. Only full 32-bit values shall be written. The register is used to write short packets and header of long packets.">
    <bitfield id="DBG" width="32" begin="31" end="0" resetval="0x0000 0000" description="32-bit input value." range="" rwaccess="W"/>
  </register>
  <register id="CSI2_COMPLEXIO_CFG" acronym="CSI2_COMPLEXIO_CFG" offset="0x50" width="32" description="COMPLEXIO CONFIGURATION REGISTER for the complex I/O This register contains the lane configuration for the order and position of the lanes (clock and data) and the polarity order for the control of the PHY differential signals in addition to the control bit for the power FSM.">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="RESET_CTRL" width="1" begin="30" end="30" resetval="0" description="Controls the reset of the complex I/O" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="RESET_CTRL_0" description="Complex I/O reset active."/>
      <bitenum value="1" id="1" token="RESET_CTRL_1" description="Complex I/O reset deasserted."/>
    </bitfield>
    <bitfield id="RESET_DONE" width="1" begin="29" end="29" resetval="0" description="Internal reset monitoring of the power domain using the byte clock provided by the associated CSIPHY (see, .Caution:For the [29] RESET_DONE bit to be set to 0x1 (reset completed), the external sensor must to be active and sending the MIPI HS BYTECLK. ." range="" rwaccess="R">
      <bitenum value="1" id="1" token="RESET_DONE_1_r" description="Reset completed."/>
      <bitenum value="0" id="0" token="RESET_DONE_0_r" description="Internal module reset is on going."/>
    </bitfield>
    <bitfield id="PWR_CMD" width="2" begin="28" end="27" resetval="0x0" description="Command for power control of the complex I/O" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="PWR_CMD_0" description="Command to change to OFF state"/>
      <bitenum value="1" id="1" token="PWR_CMD_1" description="Command to change to ON state"/>
      <bitenum value="2" id="2" token="PWR_CMD_2" description="Command to change to Ultralow-Power state"/>
    </bitfield>
    <bitfield id="PWR_STATUS" width="2" begin="26" end="25" resetval="0x0" description="Status of the power control of the complex I/O" range="" rwaccess="R">
      <bitenum value="2" id="2" token="PWR_STATUS_2_r" description="Complex I/O in Ultralow-Power state"/>
      <bitenum value="1" id="1" token="PWR_STATUS_1_r" description="Complex I/O in ON state"/>
      <bitenum value="0" id="0" token="PWR_STATUS_0_r" description="Complex I/O in OFF state"/>
    </bitfield>
    <bitfield id="PWR_AUTO" width="1" begin="24" end="24" resetval="0" description="Automatic switch between ULP and ON states based on ULPM signals from complex I/O" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="PWR_AUTO_0" description="Disable"/>
      <bitenum value="1" id="1" token="PWR_AUTO_1" description="Enable"/>
    </bitfield>
    <bitfield id="RESERVED" width="4" begin="23" end="20" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="DATA4_POL" width="1" begin="19" end="19" resetval="0" description="+/- differential pin order of data lane 4." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA4_POL_0" description="+/- pin order"/>
      <bitenum value="1" id="1" token="DATA4_POL_1" description="-/+ pin order"/>
    </bitfield>
    <bitfield id="DATA4_POSITION" width="3" begin="18" end="16" resetval="0x0" description="Position and order of the data lane 4. The values 6 and 7 are reserved. This lane is not available to the CSI2-B receiver." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA4_POSITION_0" description="This data lane is not used."/>
      <bitenum value="1" id="1" token="DATA4_POSITION_1" description="Data lane 4 is at position 1. This position is not available to the CSI2-B receiver."/>
      <bitenum value="2" id="2" token="DATA4_POSITION_2" description="Data lane 4 is at position 2. This position is not available to the CSI2-B receiver."/>
      <bitenum value="3" id="3" token="DATA4_POSITION_3" description="Data lane 4 is at position 3. This position is not available to the CSI2-B receiver."/>
      <bitenum value="4" id="4" token="DATA4_POSITION_4" description="Data lane 4 is at position 4. This position is not available to the CSI2-B receiver."/>
      <bitenum value="5" id="5" token="DATA4_POSITION_5" description="Data lane 4 is at position 5. This position is not available to the CSI2-B receiver."/>
      <bitenum value="6" id="6" token="DATA4_POSITION_6" description="Reserved"/>
      <bitenum value="7" id="7" token="DATA4_POSITION_7" description="Reserved"/>
    </bitfield>
    <bitfield id="DATA3_POL" width="1" begin="15" end="15" resetval="0" description="+/- differential pin order of data lane 3." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA3_POL_0" description="+/- pin order"/>
      <bitenum value="1" id="1" token="DATA3_POL_1" description="-/+ pin order"/>
    </bitfield>
    <bitfield id="DATA3_POSITION" width="3" begin="14" end="12" resetval="0x0" description="Position and order of the data lane 3. The values 6 and 7 are reserved. This lane is not available to the CSI2-B receiver." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA3_POSITION_0" description="This data lane is not used."/>
      <bitenum value="1" id="1" token="DATA3_POSITION_1" description="Data lane 3 is at position 1. This position is not available to the CSI2-B receiver."/>
      <bitenum value="2" id="2" token="DATA3_POSITION_2" description="Data lane 3 is at position 2. This position is not available to the CSI2-B receiver."/>
      <bitenum value="3" id="3" token="DATA3_POSITION_3" description="Data lane 3 is at position 3. This position is not available to the CSI2-B receiver."/>
      <bitenum value="4" id="4" token="DATA3_POSITION_4" description="Data lane 3 is at position 4. This position is not available to the CSI2-B receiver."/>
      <bitenum value="5" id="5" token="DATA3_POSITION_5" description="Data lane 3 is at position 5. This position is not available to the CSI2-B receiver."/>
      <bitenum value="6" id="6" token="DATA3_POSITION_6" description="Reserved"/>
      <bitenum value="7" id="7" token="DATA3_POSITION_7" description="Reserved"/>
    </bitfield>
    <bitfield id="DATA2_POL" width="1" begin="11" end="11" resetval="0" description="+/- differential pin order of DATA lane 2." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA2_POL_0" description="+/- pin order (csi2_dx=+ and csi2_dy=-)"/>
      <bitenum value="1" id="1" token="DATA2_POL_1" description="-/+ pin order (csi2_dx=- and csi2_dy=+)"/>
    </bitfield>
    <bitfield id="DATA2_POSITION" width="3" begin="10" end="8" resetval="0x0" description="Position and order of the data lane 2. The values 6 and 7 are reserved. This lane is not available to the CSI2-B receiver." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA2_POSITION_0" description="This data lane is not used."/>
      <bitenum value="1" id="1" token="DATA2_POSITION_1" description="Data lane 2 is at position 1. This position is not available to the CSI2-B receiver."/>
      <bitenum value="2" id="2" token="DATA2_POSITION_2" description="Data lane 2 is at position 2. This position is not available to the CSI2-B receiver."/>
      <bitenum value="3" id="3" token="DATA2_POSITION_3" description="Data lane 2 is at position 3. This position is not available to the CSI2-B receiver."/>
      <bitenum value="4" id="4" token="DATA2_POSITION_4" description="Data lane 2 is at position 4. This position is not available to the CSI2-B receiver."/>
      <bitenum value="5" id="5" token="DATA2_POSITION_5" description="Data lane 2 is at position 5. This position is not available to the CSI2-B receiver."/>
      <bitenum value="6" id="6" token="DATA2_POSITION_6" description="Reserved"/>
      <bitenum value="7" id="7" token="DATA2_POSITION_7" description="Reserved"/>
    </bitfield>
    <bitfield id="DATA1_POL" width="1" begin="7" end="7" resetval="0" description="+/- differential pin order of data lane 1." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA1_POL_0" description="+/- pin order (csi2_dx=+ and csi2_dy=-)"/>
      <bitenum value="1" id="1" token="DATA1_POL_1" description="-/+ pin order (csi2_dx=- and csi2_dy=+)"/>
    </bitfield>
    <bitfield id="DATA1_POSITION" width="3" begin="6" end="4" resetval="0x0" description="Position and order of the DATA lane 1.The values 6 and 7 are reserved. When CSI2 is used, the data lane 1 position must be different from 0, 6, or 7." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DATA1_POSITION_0" description="This data lane is not used."/>
      <bitenum value="1" id="1" token="DATA1_POSITION_1" description="Data lane 1 is at position 1."/>
      <bitenum value="2" id="2" token="DATA1_POSITION_2" description="Data lane 1 is at position 2."/>
      <bitenum value="3" id="3" token="DATA1_POSITION_3" description="Data lane 1 is at position 3. This position is not available to the CSI2-B receiver."/>
      <bitenum value="4" id="4" token="DATA1_POSITION_4" description="Data lane 1 is at position 4. This position is not available to the CSI2-B receiver."/>
      <bitenum value="5" id="5" token="DATA1_POSITION_5" description="Data lane 1 is at position 5. This position is not available to the CSI2-B receiver."/>
      <bitenum value="6" id="6" token="DATA1_POSITION_6" description="Reserved"/>
      <bitenum value="7" id="7" token="DATA1_POSITION_7" description="Reserved"/>
    </bitfield>
    <bitfield id="CLOCK_POL" width="1" begin="3" end="3" resetval="0" description="+/- differential pin order of clock lane." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CLOCK_POL_0" description="+/- pin order (csi2_dx=+ and csi2_dy=-)"/>
      <bitenum value="1" id="1" token="CLOCK_POL_1" description="-/+ pin order (csi2_dx=- and csi2_dy=+)"/>
    </bitfield>
    <bitfield id="CLOCK_POSITION" width="3" begin="2" end="0" resetval="0x0" description="Position and order of the clock lane. The values 5, 6, and 7 are reserved. When CSI2 is used, the clock lane position must be different from 0, 5, 6, or 7." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CLOCK_POSITION_0" description="This data lane is not used."/>
      <bitenum value="1" id="1" token="CLOCK_POSITION_1" description="Clock lane is at position 1."/>
      <bitenum value="2" id="2" token="CLOCK_POSITION_2" description="Clock lane is at position 2."/>
      <bitenum value="3" id="3" token="CLOCK_POSITION_3" description="Clock lane is at position 3. This position is not available to the CSI2-B receiver."/>
      <bitenum value="4" id="4" token="CLOCK_POSITION_4" description="Clock lane is at position 4. This position is not available to the CSI2-B receiver."/>
      <bitenum value="5" id="5" token="CLOCK_POSITION_5" description="Reserved"/>
      <bitenum value="6" id="6" token="CLOCK_POSITION_6" description="Reserved"/>
      <bitenum value="7" id="7" token="CLOCK_POSITION_7" description="Reserved"/>
    </bitfield>
  </register>
  <register id="CSI2_COMPLEXIO_IRQSTATUS" acronym="CSI2_COMPLEXIO_IRQSTATUS" offset="0x54" width="32" description="INTERRUPT STATUS REGISTER - All errors from complex I/O #1">
    <bitfield id="RESERVED" width="5" begin="31" end="27" resetval="0x00" description="" range="" rwaccess="R"/>
    <bitfield id="STATEALLULPMEXIT" width="1" begin="26" end="26" resetval="0" description="At least one of the active lanes has exit the ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEALLULPMEXIT_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEALLULPMEXIT_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEALLULPMENTER" width="1" begin="25" end="25" resetval="0" description="All active lanes are entering in ULPM." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEALLULPMENTER_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEALLULPMENTER_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEULPM5" width="1" begin="24" end="24" resetval="0" description="Lane 5 in ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEULPM5_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEULPM5_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEULPM4" width="1" begin="23" end="23" resetval="0" description="Lane 4 in ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEULPM4_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEULPM4_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEULPM3" width="1" begin="22" end="22" resetval="0" description="Lane 3 in ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEULPM3_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEULPM3_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEULPM2" width="1" begin="21" end="21" resetval="0" description="Lane 2 in ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEULPM2_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEULPM2_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="STATEULPM1" width="1" begin="20" end="20" resetval="0" description="Lane 1 in ULPM" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="STATEULPM1_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="STATEULPM1_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRCONTROL5" width="1" begin="19" end="19" resetval="0" description="Control error for lane 5" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRCONTROL5_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRCONTROL5_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRCONTROL4" width="1" begin="18" end="18" resetval="0" description="Control error for lane 4" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRCONTROL4_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRCONTROL4_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRCONTROL3" width="1" begin="17" end="17" resetval="0" description="Control error for lane 3" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRCONTROL3_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRCONTROL3_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRCONTROL2" width="1" begin="16" end="16" resetval="0" description="Control error for lane 2" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRCONTROL2_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRCONTROL2_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRCONTROL1" width="1" begin="15" end="15" resetval="0" description="Control error for lane 1" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRCONTROL1_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRCONTROL1_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRESC5" width="1" begin="14" end="14" resetval="0" description="Escape entry error for lane 5" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRESC5_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRESC5_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRESC4" width="1" begin="13" end="13" resetval="0" description="Escape entry error for lane 4" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRESC4_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRESC4_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRESC3" width="1" begin="12" end="12" resetval="0" description="Escape entry error for lane 3" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRESC3_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRESC3_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRESC2" width="1" begin="11" end="11" resetval="0" description="Escape entry error for lane 2" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRESC2_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRESC2_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRESC1" width="1" begin="10" end="10" resetval="0" description="Escape entry error for lane 1" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRESC1_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRESC1_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS5" width="1" begin="9" end="9" resetval="0" description="Start of transmission sync error for lane 5" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS5_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS5_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS4" width="1" begin="8" end="8" resetval="0" description="Start of transmission sync error for lane 4" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS4_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS4_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS3" width="1" begin="7" end="7" resetval="0" description="Start of transmission sync error for lane 3" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS3_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS3_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS2" width="1" begin="6" end="6" resetval="0" description="Start of transmission sync error for lane 2" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS2_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS2_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS1" width="1" begin="5" end="5" resetval="0" description="Start of transmission sync error for lane 1" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS1_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS1_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTHS5" width="1" begin="4" end="4" resetval="0" description="Start of transmission error for lane 5" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTHS5_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTHS5_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTHS4" width="1" begin="3" end="3" resetval="0" description="Start of transmission error for lane 4" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTHS4_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTHS4_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTHS3" width="1" begin="2" end="2" resetval="0" description="Start of transmission error for lane 3" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTHS3_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTHS3_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTHS2" width="1" begin="1" end="1" resetval="0" description="Start of transmission error for lane 2" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTHS2_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTHS2_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="ERRSOTHS1" width="1" begin="0" end="0" resetval="0" description="Start of transmission error for lane 1" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ERRSOTHS1_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ERRSOTHS1_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_SHORT_PACKET" acronym="CSI2_SHORT_PACKET" offset="0x5C" width="32" description="SHORT PACKET INFORMATION - This register sets the 24-bit DATA_ID + Short Packet Data Field when the data type is between 0x8 and x0F">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0x00" description="Reads returns 0." range="" rwaccess="R"/>
    <bitfield id="SHORT_PACKET" width="24" begin="23" end="0" resetval="0x000000" description="Short Packet information: DATA ID + DATA FIELD" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_COMPLEXIO_IRQENABLE" acronym="CSI2_COMPLEXIO_IRQENABLE" offset="0x60" width="32" description="INTERRUPT ENABLE REGISTER - All errors from complex I/O">
    <bitfield id="RESERVED" width="5" begin="31" end="27" resetval="0x00" description="" range="" rwaccess="R"/>
    <bitfield id="STATEALLULPMEXIT" width="1" begin="26" end="26" resetval="0" description="At least one of the active lanes has exit the ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEALLULPMEXIT_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEALLULPMEXIT_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEALLULPMENTER" width="1" begin="25" end="25" resetval="0" description="All active lanes are entering in ULPM." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEALLULPMENTER_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEALLULPMENTER_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEULPM5" width="1" begin="24" end="24" resetval="0" description="Lane 5 in ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEULPM5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEULPM5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEULPM4" width="1" begin="23" end="23" resetval="0" description="Lane 4 in ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEULPM4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEULPM4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEULPM3" width="1" begin="22" end="22" resetval="0" description="Lane 3 in ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEULPM3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEULPM3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEULPM2" width="1" begin="21" end="21" resetval="0" description="Lane 2 in ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEULPM2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEULPM2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="STATEULPM1" width="1" begin="20" end="20" resetval="0" description="Lane 1 in ULPM" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STATEULPM1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="STATEULPM1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRCONTROL5" width="1" begin="19" end="19" resetval="0" description="Control error for lane 5" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRCONTROL5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRCONTROL5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRCONTROL4" width="1" begin="18" end="18" resetval="0" description="Control error for lane 4" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRCONTROL4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRCONTROL4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRCONTROL3" width="1" begin="17" end="17" resetval="0" description="Control error for lane 3" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRCONTROL3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRCONTROL3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRCONTROL2" width="1" begin="16" end="16" resetval="0" description="Control error for lane 2" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRCONTROL2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRCONTROL2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRCONTROL1" width="1" begin="15" end="15" resetval="0" description="Control error for lane 1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRCONTROL1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRCONTROL1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRESC5" width="1" begin="14" end="14" resetval="0" description="Escape entry error for lane 5" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRESC5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRESC5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRESC4" width="1" begin="13" end="13" resetval="0" description="Escape entry error for lane 4" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRESC4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRESC4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRESC3" width="1" begin="12" end="12" resetval="0" description="Escape entry error for lane 3" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRESC3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRESC3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRESC2" width="1" begin="11" end="11" resetval="0" description="Escape entry error for lane 2" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRESC2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRESC2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRESC1" width="1" begin="10" end="10" resetval="0" description="Escape entry error for lane 1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRESC1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRESC1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS5" width="1" begin="9" end="9" resetval="0" description="Start of transmission sync error for lane 5" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS4" width="1" begin="8" end="8" resetval="0" description="Start of transmission sync error for lane 4" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS3" width="1" begin="7" end="7" resetval="0" description="Start of transmission sync error for lane 3" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS2" width="1" begin="6" end="6" resetval="0" description="Start of transmission sync error for lane 2" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTSYNCHS1" width="1" begin="5" end="5" resetval="0" description="Start of transmission sync error for lane 1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTSYNCHS1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTSYNCHS1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTHS5" width="1" begin="4" end="4" resetval="0" description="Start of transmission error for lane 5" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTHS5_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTHS5_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTHS4" width="1" begin="3" end="3" resetval="0" description="Start of transmission error for lane 4" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTHS4_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTHS4_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTHS3" width="1" begin="2" end="2" resetval="0" description="Start of transmission error for lane 3" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTHS3_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTHS3_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTHS2" width="1" begin="1" end="1" resetval="0" description="Start of transmission error for lane 2" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTHS2_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTHS2_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="ERRSOTHS1" width="1" begin="0" end="0" resetval="0" description="Start of transmission error for lane 1" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ERRSOTHS1_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ERRSOTHS1_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_DBG_P" acronym="CSI2_DBG_P" offset="0x68" width="32" description="DEBUG REGISTER (Payload) This register provides a way to debug the CSI2 RECEIVER module with no image sensor connected to the module. The debug mode is enabled by .DBG_EN. Only full 32-bit values shall be written. The register is used to write payload of long packets.">
    <bitfield id="DBG" width="32" begin="31" end="0" resetval="0x0000 0000" description="32-bit input value." range="" rwaccess="W"/>
  </register>
  <register id="CSI2_TIMING" acronym="CSI2_TIMING" offset="0x6C" width="32" description="TIMING REGISTER This register controls the CSI2 RECEIVER module. This register shall not be modified while .IF_EN is set to 1. It is used to indicate the number of L3 cycles for the Stop State monitoring.">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="30" end="30" resetval="1" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="1" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="13" begin="28" end="16" resetval="0x1FFF" description="Read returns reset value" range="" rwaccess="RW"/>
    <bitfield id="FORCE_RX_MODE_IO1" width="1" begin="15" end="15" resetval="0" description="Control of ForceRxMode signal" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FORCE_RX_MODE_IO1_0" description="Deassertion of ForceRxMode. The hardware reset the bit at the end of the Force RX Mode assertion. The software can reset the bit in order to stop the assertion of the ForceRXMode signal prior to the completion of the period."/>
      <bitenum value="1" id="1" token="FORCE_RX_MODE_IO1_1" description="Assertion of ForceRxMode"/>
    </bitfield>
    <bitfield id="STOP_STATE_X16_IO1" width="1" begin="14" end="14" resetval="1" description="Multiplication factor for the number of L3 cycles defined in STOP_STATE_COUNTER bit field" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STOP_STATE_X16_IO1_0" description="The number of L3 cycles defined in STOP_STATE _COUNTER is multiplied by 1x"/>
      <bitenum value="1" id="1" token="STOP_STATE_X16_IO1_1" description="The number of L3 cycles defined in STOP_STATE _COUNTER is multiplied by 16x"/>
    </bitfield>
    <bitfield id="STOP_STATE_X4_IO1" width="1" begin="13" end="13" resetval="1" description="Multiplication factor for the number of L3 cycles defined in STOP_STATE_COUNTER bit field" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="STOP_STATE_X4_IO1_0" description="The number of L3 cycles defined in STOP_STATE _COUNTER is multiplied by 1x"/>
      <bitenum value="1" id="1" token="STOP_STATE_X4_IO1_1" description="The number of L3 cycles defined in STOP_STATE _COUNTER is multiplied by 4x"/>
    </bitfield>
    <bitfield id="STOP_STATE_COUNTER_IO1" width="13" begin="12" end="0" resetval="0x1FFF" description="Stop State counter for monitoring. It indicates the number of L3 to monitor for Stop State before deasserting ForceRxMode (complex I/O 1). The value is from 0 to 8191." range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL1_i_0" acronym="CSI2_CTX_CTRL1_i_0" offset="0x70" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_1" acronym="CSI2_CTX_CTRL1_i_1" offset="0x90" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_2" acronym="CSI2_CTX_CTRL1_i_2" offset="0xB0" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_3" acronym="CSI2_CTX_CTRL1_i_3" offset="0xD0" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_4" acronym="CSI2_CTX_CTRL1_i_4" offset="0xF0" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_5" acronym="CSI2_CTX_CTRL1_i_5" offset="0x110" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_6" acronym="CSI2_CTX_CTRL1_i_6" offset="0x130" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL1_i_7" acronym="CSI2_CTX_CTRL1_i_7" offset="0x150" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="BYTESWAP" width="1" begin="31" end="31" resetval="0" description="Allows swapping bytes two by two in the payload data. It does not affect: - short packets - long packet header or footers - CRC calculation The purpose is to by swap data send to the OCP port and/or video port" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="BYTESWAP_0" description="Disabled"/>
      <bitenum value="1" id="1" token="BYTESWAP_1" description="Enabled"/>
    </bitfield>
    <bitfield id="GENERIC" width="1" begin="30" end="30" resetval="0" description="Enables the generic mode." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="GENERIC_0" description="Disabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is used."/>
      <bitenum value="1" id="1" token="GENERIC_1" description="Enabled. Data is received according to CSI2_CTX_CTRL1.FORMAT and the long packet code transmitted in the MIPI stream is ignored."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="29" end="29" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="HSCALE" width="1" begin="28" end="28" resetval="0x0" description="Enable horizontal downscaling by a factor of two. Applies to RAW data when transcoding is enabled. 0x0: Disable 0x1: Enable" range="" rwaccess="RW"/>
    <bitfield id="TRANSCODE" width="4" begin="27" end="24" resetval="0x0" description="Enables image transcoding. When this features is enabled: - the data format from the camera is defined by the FORMAT register - the format after transcode is defined by the TRANSCODE register. The memory storage / video port formats is defined by the TRANSCODE register" range="" rwaccess="RW">
      <bitenum value="6" id="6" token="TRANSCODE_6" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular packed RAW10 data"/>
      <bitenum value="1" id="1" token="TRANSCODE_1" description="Outputs DPCM compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="7" id="7" token="TRANSCODE_7" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular RAW12+EXP16 data"/>
      <bitenum value="0" id="0" token="TRANSCODE_0" description="Feature disabled."/>
      <bitenum value="2" id="2" token="TRANSCODE_2" description="Outputs DPCM compressed RAW12 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="8" id="8" token="TRANSCODE_8" description="Outputs uncompressed RAW12 data. Data in memory is organized as regular packed RAW12 data"/>
      <bitenum value="9" id="9" token="TRANSCODE_9" description="Outputs uncompressed RAW14 data."/>
      <bitenum value="4" id="4" token="TRANSCODE_4" description="Outputs uncompressed RAW8 data. Data in memory is organized as regular RAW8 data"/>
      <bitenum value="5" id="5" token="TRANSCODE_5" description="Outputs uncompressed RAW10 data. Data in memory is organized as regular RAW10+EXP16 data"/>
      <bitenum value="3" id="3" token="TRANSCODE_3" description="Outputs A-Law compressed RAW10 data. After compression, pixels are coded on 8 bits. Data in memory is organized as regular RAW8 data."/>
    </bitfield>
    <bitfield id="FEC_NUMBER" width="8" begin="23" end="16" resetval="0x01" description="Number of FEC to receive between using swap of CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR for the calculation of the address in memory (must be used only in interlace mode, otherwise set to 1)." range="" rwaccess="RW"/>
    <bitfield id="COUNT" width="8" begin="15" end="8" resetval="0x00" description="Sets the number of frame to acquire. Once the frame acquisition starts, the COUNT value is decremented after every frame. When COUNT reaches 0, the FRAME_NUMBER_IRQ interrupt is triggered and CTX_EN is set to 0. Writes to this bit field are controlled by the COUNT_UNLOCK bit. During the same OCP write access, the bit field COUNT_UNLOCK shall be written in addition to COUNT bit field in order to change the COUNT value. COUNT can be overwritten dynamically with a new count value. 0: Infinite number of frames (no count). 1: 1 frame to acquire ... 255: 255 frames to acquire" range="" rwaccess="RW"/>
    <bitfield id="EOF_EN" width="1" begin="7" end="7" resetval="0" description="Indicates if the end of frame signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOF_EN_1_r" description="The end of frame signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOF_EN_0_r" description="The end of frame signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="EOL_EN" width="1" begin="6" end="6" resetval="0" description="Indicates if the end of line signal shall be asserted at the end of the line." range="" rwaccess="RW">
      <bitenum value="1" id="1" token="EOL_EN_1_r" description="The end of line signal is asserted at the end of each frame."/>
      <bitenum value="0" id="0" token="EOL_EN_0_r" description="The end of line signal is not asserted at the end of each frame."/>
    </bitfield>
    <bitfield id="CS_EN" width="1" begin="5" end="5" resetval="0" description="Enables the checksum check for the received payload (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CS_EN_1" description="Enabled"/>
    </bitfield>
    <bitfield id="COUNT_UNLOCK" width="1" begin="4" end="4" resetval="0" description="Unlock writes to the COUNT bit field." range="" rwaccess="W">
      <bitenum value="0" id="0" token="COUNT_UNLOCK_0_w" description="COUNT bit field is locked. Writes have no effect"/>
      <bitenum value="1" id="1" token="COUNT_UNLOCK_1_w" description="COUNT bit field is unlocked. Writes are possible."/>
    </bitfield>
    <bitfield id="PING_PONG" width="1" begin="3" end="3" resetval="1" description="Indicates whether the PING or PONG destination address (CSI2_CTX_DAT_PING_ADDR or CSI2_CTX_DAT_PONG_ADDR) was used to write the last frame. This bit field toggles after every FEC_NUMBER FEC sync code received for the current context." range="" rwaccess="R">
      <bitenum value="1" id="1" token="PING_PONG_1_r" description="PONG buffer"/>
      <bitenum value="0" id="0" token="PING_PONG_0_r" description="PING buffer"/>
    </bitfield>
    <bitfield id="VP_FORCE" width="1" begin="2" end="2" resetval="0" description="Forces sending of the data to both VPORT and OCP. Only applies to formats that existing in two versions: - One sending data to OCP port only - One sending data to VPORT only (tagged with the +VP extension) The format version sending data only to OCP should be chosen." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VP_FORCE_0" description="Disabled"/>
      <bitenum value="1" id="1" token="VP_FORCE_1" description="Enabled"/>
    </bitfield>
    <bitfield id="LINE_MODULO" width="1" begin="1" end="1" resetval="0" description="Line modulo configuration" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_MODULO_0" description="CSI2_CTX_CTRL3.LINE_NUMBER is used once per frame for the generation of the LINE_NUMBER_IRQ."/>
      <bitenum value="1" id="1" token="LINE_MODULO_1" description="CSI2_CTX_CTRL3.LINE_NUMBER is used as a modulo number for the generation of the LINE_NUMBER_IRQ (multiple times the interrupt can be generated for each frame)"/>
    </bitfield>
    <bitfield id="CTX_EN" width="1" begin="0" end="0" resetval="0" description="Enables the context" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CTX_EN_0" description="Disabled"/>
      <bitenum value="1" id="1" token="CTX_EN_1" description="Enabled"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_0" acronym="CSI2_CTX_CTRL2_i_0" offset="0x74" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_1" acronym="CSI2_CTX_CTRL2_i_1" offset="0x94" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_2" acronym="CSI2_CTX_CTRL2_i_2" offset="0xB4" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_3" acronym="CSI2_CTX_CTRL2_i_3" offset="0xD4" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_4" acronym="CSI2_CTX_CTRL2_i_4" offset="0xF4" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_5" acronym="CSI2_CTX_CTRL2_i_5" offset="0x114" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_6" acronym="CSI2_CTX_CTRL2_i_6" offset="0x134" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL2_i_7" acronym="CSI2_CTX_CTRL2_i_7" offset="0x154" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code (except for VIRTUAL_ID and FORMAT fields). The change of VIRTUIAL_ID and FORMAT has to occur only when the context is disabled (CSI2_CTX_CTRL1.CTX_EN).">
    <bitfield id="FRAME" width="16" begin="31" end="16" resetval="0x0000" description="Frame number received" range="" rwaccess="R"/>
    <bitfield id="RESERVED" width="1" begin="15" end="15" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="USER_DEF_MAPPING" width="2" begin="14" end="13" resetval="0x0" description="Selects the pixel format of USER_DEFINED in FORMAT" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="USER_DEF_MAPPING_0" description="RAW6"/>
      <bitenum value="1" id="1" token="USER_DEF_MAPPING_1" description="RAW7"/>
      <bitenum value="2" id="2" token="USER_DEF_MAPPING_2" description="RAW8 (not valid if FORMAT is USER_DEFINED_8_BIT_DATA_TYPE_x_EXP8 with x from 1 to 8)"/>
    </bitfield>
    <bitfield id="VIRTUAL_ID" width="2" begin="12" end="11" resetval="0x0" description="Virtual channel ID" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="VIRTUAL_ID_0" description="Virtual Channel ID 0"/>
      <bitenum value="1" id="1" token="VIRTUAL_ID_1" description="Virtual Channel ID 1"/>
      <bitenum value="3" id="3" token="VIRTUAL_ID_3" description="Virtual Channel ID 3"/>
      <bitenum value="2" id="2" token="VIRTUAL_ID_2" description="Virtual Channel ID 2"/>
    </bitfield>
    <bitfield id="DPCM_PRED" width="1" begin="10" end="10" resetval="0" description="Selects the DPCM predictor." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="DPCM_PRED_0" description="The advanced predictor is used. Not supported for 10- 8- 10 algorithm. Performance limited to 1 pixel/cycle."/>
      <bitenum value="1" id="1" token="DPCM_PRED_1" description="The simple predictor is used."/>
    </bitfield>
    <bitfield id="FORMAT" width="10" begin="9" end="0" resetval="0x000" description="Data format selection." range="" rwaccess="RW">
      <bitenum value="937" id="937" token="FORMAT_937" description="RAW7 DPCM12 + VP"/>
      <bitenum value="128" id="128" token="FORMAT_128" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + EXP8"/>
      <bitenum value="132" id="132" token="FORMAT_132" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + EXP8"/>
      <bitenum value="838" id="838" token="FORMAT_838" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + VP"/>
      <bitenum value="29" id="29" token="FORMAT_29" description="YUV4:2:0 10bit + CSPS"/>
      <bitenum value="710" id="710" token="FORMAT_710" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + DPCM10 + EXP16"/>
      <bitenum value="65" id="65" token="FORMAT_65" description="USER_DEFINED_8_BIT_DATA_TYPE_2"/>
      <bitenum value="453" id="453" token="FORMAT_453" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_EXP16"/>
      <bitenum value="172" id="172" token="FORMAT_172" description="RAW12 + EXP16"/>
      <bitenum value="325" id="325" token="FORMAT_325" description="USER_DEFINED_8_BIT_DATA_TYPE_6_DPCM12_VP"/>
      <bitenum value="18" id="18" token="FORMAT_18" description="Embedded 8-bit nonimage data (that is, JPEG)"/>
      <bitenum value="70" id="70" token="FORMAT_70" description="USER_DEFINED_8_BIT_DATA_TYPE_7"/>
      <bitenum value="131" id="131" token="FORMAT_131" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + EXP8"/>
      <bitenum value="43" id="43" token="FORMAT_43" description="RAW10"/>
      <bitenum value="158" id="158" token="FORMAT_158" description="YUV4:2:2 8bit + VP"/>
      <bitenum value="448" id="448" token="FORMAT_448" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_EXP16"/>
      <bitenum value="320" id="320" token="FORMAT_320" description="USER_DEFINED_8_BIT_DATA_TYPE_1_DPCM12_VP"/>
      <bitenum value="809" id="809" token="FORMAT_809" description="RAW7 + DPCM10 + VP"/>
      <bitenum value="34" id="34" token="FORMAT_34" description="RGB565"/>
      <bitenum value="104" id="104" token="FORMAT_104" description="RAW6 + EXP8"/>
      <bitenum value="67" id="67" token="FORMAT_67" description="USER_DEFINED_8_BIT_DATA_TYPE_4"/>
      <bitenum value="227" id="227" token="FORMAT_227" description="RGB666 + EXP32"/>
      <bitenum value="455" id="455" token="FORMAT_455" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_EXP16"/>
      <bitenum value="323" id="323" token="FORMAT_323" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_VP"/>
      <bitenum value="160" id="160" token="FORMAT_160" description="RGB444 + EXP16"/>
      <bitenum value="135" id="135" token="FORMAT_135" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + EXP8"/>
      <bitenum value="133" id="133" token="FORMAT_133" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + EXP8"/>
      <bitenum value="0" id="0" token="FORMAT_0" description="OTHERS (except NULL and BLANKING packets)"/>
      <bitenum value="833" id="833" token="FORMAT_833" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + VP"/>
      <bitenum value="173" id="173" token="FORMAT_173" description="RAW14 + EXP16"/>
      <bitenum value="707" id="707" token="FORMAT_707" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + EXP16"/>
      <bitenum value="228" id="228" token="FORMAT_228" description="RGB888 + EXP32"/>
      <bitenum value="835" id="835" token="FORMAT_835" description="USER_DEFINED_8_BIT_DATA_TYPE_4 + DPCM10 + VP"/>
      <bitenum value="872" id="872" token="FORMAT_872" description="RAW6 DPCM12 + VP"/>
      <bitenum value="300" id="300" token="FORMAT_300" description="RAW12 + VP"/>
      <bitenum value="66" id="66" token="FORMAT_66" description="USER_DEFINED_8_BIT_DATA_TYPE_3"/>
      <bitenum value="161" id="161" token="FORMAT_161" description="RGB555 + EXP16"/>
      <bitenum value="301" id="301" token="FORMAT_301" description="RAW14 + VP"/>
      <bitenum value="324" id="324" token="FORMAT_324" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_VP"/>
      <bitenum value="452" id="452" token="FORMAT_452" description="USER_DEFINED_8_BIT_DATA_TYPE_5_DPCM12_EXP16"/>
      <bitenum value="42" id="42" token="FORMAT_42" description="RAW8"/>
      <bitenum value="938" id="938" token="FORMAT_938" description="RAW8 DPCM12 + VP"/>
      <bitenum value="705" id="705" token="FORMAT_705" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + DPCM10 + EXP16"/>
      <bitenum value="451" id="451" token="FORMAT_451" description="USER_DEFINED_8_BIT_DATA_TYPE_4_DPCM12_EXP16"/>
      <bitenum value="834" id="834" token="FORMAT_834" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + VP"/>
      <bitenum value="322" id="322" token="FORMAT_322" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_VP"/>
      <bitenum value="26" id="26" token="FORMAT_26" description="YUV4:2:0 8bit legacy"/>
      <bitenum value="874" id="874" token="FORMAT_874" description="RAW8 DPCM12 + EXP16"/>
      <bitenum value="810" id="810" token="FORMAT_810" description="RAW8 + DPCM10 + VP"/>
      <bitenum value="553" id="553" token="FORMAT_553" description="RAW7 + DPCM10 + EXP16"/>
      <bitenum value="298" id="298" token="FORMAT_298" description="RAW8 + VP"/>
      <bitenum value="40" id="40" token="FORMAT_40" description="RAW6"/>
      <bitenum value="449" id="449" token="FORMAT_449" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_EXP16"/>
      <bitenum value="680" id="680" token="FORMAT_680" description="RAW6 + DPCM10 + EXP16"/>
      <bitenum value="69" id="69" token="FORMAT_69" description="USER_DEFINED_8_BIT_DATA_TYPE_6"/>
      <bitenum value="222" id="222" token="FORMAT_222" description="Same as YUV4:2:2 8bit + VP but data is send as 16-bit wide words to video port. Could be used together with the GENERIC and BYTESWAP features."/>
      <bitenum value="832" id="832" token="FORMAT_832" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + VP"/>
      <bitenum value="64" id="64" token="FORMAT_64" description="USER_DEFINED_8_BIT_DATA_TYPE_1"/>
      <bitenum value="25" id="25" token="FORMAT_25" description="YUV4:2:0 10 bit"/>
      <bitenum value="836" id="836" token="FORMAT_836" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + VP"/>
      <bitenum value="706" id="706" token="FORMAT_706" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + DPCM10 + EXP16"/>
      <bitenum value="321" id="321" token="FORMAT_321" description="USER_DEFINED_8_BIT_DATA_TYPE_2_DPCM12_VP"/>
      <bitenum value="873" id="873" token="FORMAT_873" description="RAW7 DPCM12 + EXP16"/>
      <bitenum value="105" id="105" token="FORMAT_105" description="RAW7 + EXP8"/>
      <bitenum value="708" id="708" token="FORMAT_708" description="USER_DEFINED_8_BIT_DATA_TYPE_5 + DPCM10 + EXP16"/>
      <bitenum value="28" id="28" token="FORMAT_28" description="YUV4:2:0 8 bit + CSPS"/>
      <bitenum value="839" id="839" token="FORMAT_839" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + VP"/>
      <bitenum value="326" id="326" token="FORMAT_326" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_VP"/>
      <bitenum value="130" id="130" token="FORMAT_130" description="USER_DEFINED_8_BIT_DATA_TYPE_3 + EXP8"/>
      <bitenum value="71" id="71" token="FORMAT_71" description="USER_DEFINED_8_BIT_DATA_TYPE_8"/>
      <bitenum value="682" id="682" token="FORMAT_682" description="RAW8 + DPCM10 + EXP16"/>
      <bitenum value="30" id="30" token="FORMAT_30" description="YUV4:2:2 8 bit"/>
      <bitenum value="51" id="51" token="FORMAT_51" description="RGB666 + EXP32_24"/>
      <bitenum value="44" id="44" token="FORMAT_44" description="RAW12"/>
      <bitenum value="711" id="711" token="FORMAT_711" description="USER_DEFINED_8_BIT_DATA_TYPE_8 + DPCM10 + EXP16"/>
      <bitenum value="327" id="327" token="FORMAT_327" description="USER_DEFINED_8_BIT_DATA_TYPE_8_DPCM12_VP"/>
      <bitenum value="129" id="129" token="FORMAT_129" description="USER_DEFINED_8_BIT_DATA_TYPE_2 + EXP8"/>
      <bitenum value="36" id="36" token="FORMAT_36" description="RGB888"/>
      <bitenum value="45" id="45" token="FORMAT_45" description="RAW14"/>
      <bitenum value="837" id="837" token="FORMAT_837" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + VP"/>
      <bitenum value="171" id="171" token="FORMAT_171" description="RAW10 + EXP16"/>
      <bitenum value="936" id="936" token="FORMAT_936" description="RAW6 DPCM12 + EXP16"/>
      <bitenum value="68" id="68" token="FORMAT_68" description="USER_DEFINED_8_BIT_DATA_TYPE_5"/>
      <bitenum value="704" id="704" token="FORMAT_704" description="USER_DEFINED_8_BIT_DATA_TYPE_1 + DPCM10 + EXP16"/>
      <bitenum value="24" id="24" token="FORMAT_24" description="YUV4:2:0 8 bit"/>
      <bitenum value="303" id="303" token="FORMAT_303" description="RAW10 + VP"/>
      <bitenum value="232" id="232" token="FORMAT_232" description="RAW6 + DPCM10 + VP"/>
      <bitenum value="31" id="31" token="FORMAT_31" description="YUV4:2:2 10 bit"/>
      <bitenum value="709" id="709" token="FORMAT_709" description="USER_DEFINED_8_BIT_DATA_TYPE_6 + DPCM10 + EXP16"/>
      <bitenum value="450" id="450" token="FORMAT_450" description="USER_DEFINED_8_BIT_DATA_TYPE_3_DPCM12_EXP16"/>
      <bitenum value="454" id="454" token="FORMAT_454" description="USER_DEFINED_8_BIT_DATA_TYPE_7_DPCM12_EXP16"/>
      <bitenum value="41" id="41" token="FORMAT_41" description="RAW7"/>
      <bitenum value="134" id="134" token="FORMAT_134" description="USER_DEFINED_8_BIT_DATA_TYPE_7 + EXP8"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_0" acronym="CSI2_CTX_DAT_OFST_i_0" offset="0x78" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_1" acronym="CSI2_CTX_DAT_OFST_i_1" offset="0x98" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_2" acronym="CSI2_CTX_DAT_OFST_i_2" offset="0xB8" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_3" acronym="CSI2_CTX_DAT_OFST_i_3" offset="0xD8" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_4" acronym="CSI2_CTX_DAT_OFST_i_4" offset="0xF8" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_5" acronym="CSI2_CTX_DAT_OFST_i_5" offset="0x118" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_6" acronym="CSI2_CTX_DAT_OFST_i_6" offset="0x138" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_OFST_i_7" acronym="CSI2_CTX_DAT_OFST_i_7" offset="0x158" width="32" description="DATA MEM ADDRESS OFFSET REGISTER - Context This register sets the offset, which is applied on the destination address after each line is written to memory. This register applies for both CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR. For example, it enables to perform 2D data transfers of the pixel data into a frame buffer. In such case, the pixel data and frame buffer data shall have the same data format. The 5 LSBs are ignored: the offset shall be a multiple of 32 bytes. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="RESERVED" width="15" begin="31" end="17" resetval="0x0000" description="" range="" rwaccess="R"/>
    <bitfield id="OFST" width="12" begin="16" end="5" resetval="0x000" description="Line offset programmed in bytes (signed value 2s complement). If OFST = 0, the data is written contiguously in memory. Otherwise, OFST sets the destination offset between the first pixel of the previous line and the first pixel of the current line." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_0" acronym="CSI2_CTX_DAT_PING_ADDR_i_0" offset="0x7C" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_1" acronym="CSI2_CTX_DAT_PING_ADDR_i_1" offset="0x9C" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_2" acronym="CSI2_CTX_DAT_PING_ADDR_i_2" offset="0xBC" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_3" acronym="CSI2_CTX_DAT_PING_ADDR_i_3" offset="0xDC" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_4" acronym="CSI2_CTX_DAT_PING_ADDR_i_4" offset="0xFC" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_5" acronym="CSI2_CTX_DAT_PING_ADDR_i_5" offset="0x11C" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_6" acronym="CSI2_CTX_DAT_PING_ADDR_i_6" offset="0x13C" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PING_ADDR_i_7" acronym="CSI2_CTX_DAT_PING_ADDR_i_7" offset="0x15C" width="32" description="DATA MEM PING ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double buffered: this register sets the PING address. Double buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_0" acronym="CSI2_CTX_DAT_PONG_ADDR_i_0" offset="0x80" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_1" acronym="CSI2_CTX_DAT_PONG_ADDR_i_1" offset="0xA0" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_2" acronym="CSI2_CTX_DAT_PONG_ADDR_i_2" offset="0xC0" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_3" acronym="CSI2_CTX_DAT_PONG_ADDR_i_3" offset="0xE0" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_4" acronym="CSI2_CTX_DAT_PONG_ADDR_i_4" offset="0x100" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_5" acronym="CSI2_CTX_DAT_PONG_ADDR_i_5" offset="0x120" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_6" acronym="CSI2_CTX_DAT_PONG_ADDR_i_6" offset="0x140" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_DAT_PONG_ADDR_i_7" acronym="CSI2_CTX_DAT_PONG_ADDR_i_7" offset="0x160" width="32" description="DATA MEM PONG ADDRESS REGISTER - Context This register sets the 32-bit memory address where the pixel data are stored. The destination is double-buffered: this register sets the PONG address. Double-buffering is enabled when the addresses CSI2_CTX_DAT_PING_ADDR and CSI2_CTX_DAT_PONG_ADDR are different. The 5 LSBs are ignored: the address shall be aligned on a 32-byte boundary. This register is shadowed: modifications are taken into account after the next FSC sync code. Only full 32-bit values shall be written.">
    <bitfield id="ADDR" width="27" begin="31" end="5" resetval="0x0000000" description="27 most-significant bits of the 32-bit address." range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="4" end="0" resetval="0x00" description="" range="" rwaccess="R"/>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_0" acronym="CSI2_CTX_IRQENABLE_i_0" offset="0x84" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_1" acronym="CSI2_CTX_IRQENABLE_i_1" offset="0xA4" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_2" acronym="CSI2_CTX_IRQENABLE_i_2" offset="0xC4" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_3" acronym="CSI2_CTX_IRQENABLE_i_3" offset="0xE4" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_4" acronym="CSI2_CTX_IRQENABLE_i_4" offset="0x104" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_5" acronym="CSI2_CTX_IRQENABLE_i_5" offset="0x124" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_6" acronym="CSI2_CTX_IRQENABLE_i_6" offset="0x144" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQENABLE_i_7" acronym="CSI2_CTX_IRQENABLE_i_7" offset="0x164" width="32" description="INTERRUPT ENABLE REGISTER - Context This register regroups all the events related to context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to correct the only 1-bit error (long packet only)." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number is reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum of the payload mismatch detection" range="" rwaccess="RW">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection." range="" rwaccess="RW">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="Event is masked"/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="Event generates an interrupt when it occurs"/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_0" acronym="CSI2_CTX_IRQSTATUS_i_0" offset="0x88" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_1" acronym="CSI2_CTX_IRQSTATUS_i_1" offset="0xA8" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_2" acronym="CSI2_CTX_IRQSTATUS_i_2" offset="0xC8" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_3" acronym="CSI2_CTX_IRQSTATUS_i_3" offset="0xE8" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_4" acronym="CSI2_CTX_IRQSTATUS_i_4" offset="0x108" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_5" acronym="CSI2_CTX_IRQSTATUS_i_5" offset="0x128" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_6" acronym="CSI2_CTX_IRQSTATUS_i_6" offset="0x148" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_IRQSTATUS_i_7" acronym="CSI2_CTX_IRQSTATUS_i_7" offset="0x168" width="32" description="INTERRUPT STATUS REGISTER - Context This register regroups all the events related to Context.">
    <bitfield id="RESERVED" width="23" begin="31" end="9" resetval="0x000000" description="" range="" rwaccess="R"/>
    <bitfield id="ECC_CORRECTION_IRQ" width="1" begin="8" end="8" resetval="0" description="Context - ECC has been used to do the correction of the only 1-bit error status (long packet only)." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="ECC_CORRECTION_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="ECC_CORRECTION_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LINE_NUMBER_IRQ" width="1" begin="7" end="7" resetval="0" description="Context - Line number reached status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LINE_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LINE_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FRAME_NUMBER_IRQ" width="1" begin="6" end="6" resetval="0" description="Context - Frame counter reached status" range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FRAME_NUMBER_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FRAME_NUMBER_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="CS_IRQ" width="1" begin="5" end="5" resetval="0" description="Context - Check-Sum mismatch status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="CS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="CS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="RESERVED" width="1" begin="4" end="4" resetval="0" description="" range="" rwaccess="R"/>
    <bitfield id="LE_IRQ" width="1" begin="3" end="3" resetval="0" description="Context - Line end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="LS_IRQ" width="1" begin="2" end="2" resetval="0" description="Context - Line start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="LS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="LS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FE_IRQ" width="1" begin="1" end="1" resetval="0" description="Context - Frame end sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FE_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FE_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
    <bitfield id="FS_IRQ" width="1" begin="0" end="0" resetval="0" description="Context - Frame start sync code detection status." range="" rwaccess="RW W1toClr">
      <bitenum value="0" id="0" token="FS_IRQ_0" description="READS: Event is false. WRITES: Status bit unchanged."/>
      <bitenum value="1" id="1" token="FS_IRQ_1" description="READS: Event is true (pending). WRITES: Status bit is reset."/>
    </bitfield>
  </register>
  <register id="CSI2_CTX_CTRL3_i_0" acronym="CSI2_CTX_CTRL3_i_0" offset="0x8C" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_1" acronym="CSI2_CTX_CTRL3_i_1" offset="0xAC" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_2" acronym="CSI2_CTX_CTRL3_i_2" offset="0xCC" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_3" acronym="CSI2_CTX_CTRL3_i_3" offset="0xEC" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_4" acronym="CSI2_CTX_CTRL3_i_4" offset="0x10C" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_5" acronym="CSI2_CTX_CTRL3_i_5" offset="0x12C" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_6" acronym="CSI2_CTX_CTRL3_i_6" offset="0x14C" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
  <register id="CSI2_CTX_CTRL3_i_7" acronym="CSI2_CTX_CTRL3_i_7" offset="0x16C" width="32" description="CONTROL REGISTER - Context This register controls the Context. This register is shadowed: modifications are taken into account after the next FSC sync code.">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0x0" description="" range="" rwaccess="R"/>
    <bitfield id="ALPHA" width="14" begin="29" end="16" resetval="0x0000" description="Alpha value for RGB888, RGB666 and RBG444." range="" rwaccess="RW"/>
    <bitfield id="LINE_NUMBER" width="16" begin="15" end="0" resetval="0x0000" description="Line number for the interrupt generation" range="" rwaccess="RW"/>
  </register>
</module>
