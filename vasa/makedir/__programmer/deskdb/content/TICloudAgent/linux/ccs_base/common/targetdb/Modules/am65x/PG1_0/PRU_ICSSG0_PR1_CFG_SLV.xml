<module name="PRU_ICSSG0_PR1_CFG_SLV" acronym="" XML_version="1.0" HW_revision="n/a" description="">
  <register id="ICSSG_PID_REG" acronym="ICSSG_PID_REG" offset="0x0" width="32" description="Register">
    <bitfield id="ICSS_IDVER" width="32" begin="31" end="0" resetval="0x6B00C100" description="Module ID field" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_HWDIS_REG" acronym="ICSSG_HWDIS_REG" offset="0x4" width="32" description="HW Disable Register">
    <bitfield id="RESERVED" width="24" begin="31" end="8" resetval="0xX" description="" range="" rwaccess="R"/>
    <bitfield id="HWDIS" width="8" begin="7" end="0" resetval="0xX" description="Read the state of the efuse bits which drive pr1_hw_disable[7:0]" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_GPCFG0_REG" acronym="ICSSG_GPCFG0_REG" offset="0x8" width="32" description="GP Configuration 0 Register">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PR1_PRU0_GP_MUX_SEL" width="4" begin="29" end="26" resetval="0x0" description="Controls the icss_wrap mux sel" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SH1_SEL" width="1" begin="25" end="25" resetval="0x0" description="This defines which shadow register is currently getting used for GPO shifting." range="" rwaccess="R"/>
    <bitfield id="PRU0_GPO_DIV1" width="5" begin="24" end="20" resetval="0x0" description="Divisor value , divide by PRU0_GPO_DIV1 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_DIV0" width="5" begin="19" end="15" resetval="0x0" description="Divisor value , divide by PRU0_GPO_DIV0 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_MODE" width="1" begin="14" end="14" resetval="0x0" description="0x0 = Parallel output mode" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_SB" width="1" begin="13" end="13" resetval="0x0" description="PRU0_GPI_SB set when first capture on 1 on r31_status[0]" range="" rwaccess="RW1C"/>
    <bitfield id="PRU0_GPI_DIV1" width="5" begin="12" end="8" resetval="0x0" description="Divisor value , divide by PRU0_GPI_DIV1 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_DIV0" width="5" begin="7" end="3" resetval="0x0" description="Divisor value , divide by PRU0_GPI_DIV0 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_CLK_MODE" width="1" begin="2" end="2" resetval="0x0" description="Parallel 16-bit capture mode clock edge" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_MODE" width="2" begin="1" end="0" resetval="0x0" description="0x0 = Direct connect of pru&amp;amp;lt;n&amp;amp;gt;_r31_status[29:0]" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_GPCFG1_REG" acronym="ICSSG_GPCFG1_REG" offset="0xC" width="32" description="GP Configuration 1 Register">
    <bitfield id="RESERVED" width="2" begin="31" end="30" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PR1_PRU1_GP_MUX_SEL" width="4" begin="29" end="26" resetval="0x0" description="Controls the icss_wrap mux sel" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SH1_SEL" width="1" begin="25" end="25" resetval="0x0" description="This defines which shadow register is currently getting used for GPO shifting." range="" rwaccess="R"/>
    <bitfield id="PRU1_GPO_DIV1" width="5" begin="24" end="20" resetval="0x0" description="Divisor value , divide by PRU1_GPO_DIV1 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_DIV0" width="5" begin="19" end="15" resetval="0x0" description="Divisor value , divide by PRU1_GPO_DIV0 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_MODE" width="1" begin="14" end="14" resetval="0x0" description="0x0 = Parallel output mode" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_SB" width="1" begin="13" end="13" resetval="0x0" description="PRU1_GPI_SB set when first capture on 1 on r31_status[0]" range="" rwaccess="RW1C"/>
    <bitfield id="PRU1_GPI_DIV1" width="5" begin="12" end="8" resetval="0x0" description="Divisor value , divide by PRU1_GPI_DIV1 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_DIV0" width="5" begin="7" end="3" resetval="0x0" description="Divisor value , divide by PRU1_GPI_DIV0 + 1" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_CLK_MODE" width="1" begin="2" end="2" resetval="0x0" description="Parallel 16-bit capture mode clock edge" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_MODE" width="2" begin="1" end="0" resetval="0x0" description="0x0 = Direct connect of pru&amp;amp;lt;n&amp;amp;gt;_r31_status[29:0]" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_CGR_REG" acronym="ICSSG_CGR_REG" offset="0x10" width="32" description="Clock Gating Register">
    <bitfield id="ICSS_STOP_ACK" width="1" begin="31" end="31" resetval="0x1" description="ICSS" range="" rwaccess="RW"/>
    <bitfield id="ICSS_STOP_REQ" width="1" begin="30" end="30" resetval="0x0" description="ICSS" range="" rwaccess="R"/>
    <bitfield id="ICSS_PWR_IDLE" width="1" begin="29" end="29" resetval="0x1" description="ICSS" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="11" begin="28" end="18" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="IEP_CLK_EN" width="1" begin="17" end="17" resetval="0x1" description="IEP" range="" rwaccess="RW"/>
    <bitfield id="IEP_CLK_STOP_ACK" width="1" begin="16" end="16" resetval="0x0" description="IEP" range="" rwaccess="R"/>
    <bitfield id="IEP_CLK_STOP_REQ" width="1" begin="15" end="15" resetval="0x0" description="IEP" range="" rwaccess="RW"/>
    <bitfield id="ECAP_CLK_EN" width="1" begin="14" end="14" resetval="0x1" description="ECAP" range="" rwaccess="RW"/>
    <bitfield id="ECAP_CLK_STOP_ACK" width="1" begin="13" end="13" resetval="0x0" description="ECAP" range="" rwaccess="R"/>
    <bitfield id="ECAP_CLK_STOP_REQ" width="1" begin="12" end="12" resetval="0x0" description="ECAP" range="" rwaccess="RW"/>
    <bitfield id="UART_CLK_EN" width="1" begin="11" end="11" resetval="0x1" description="UART" range="" rwaccess="RW"/>
    <bitfield id="UART_CLK_STOP_ACK" width="1" begin="10" end="10" resetval="0x0" description="UART" range="" rwaccess="R"/>
    <bitfield id="UART_CLK_STOP_REQ" width="1" begin="9" end="9" resetval="0x0" description="UART" range="" rwaccess="RW"/>
    <bitfield id="INTC_CLK_EN" width="1" begin="8" end="8" resetval="0x1" description="INTC" range="" rwaccess="RW"/>
    <bitfield id="INTC_CLK_STOP_ACK" width="1" begin="7" end="7" resetval="0x0" description="INTC" range="" rwaccess="R"/>
    <bitfield id="INTC_CLK_STOP_REQ" width="1" begin="6" end="6" resetval="0x0" description="INTC" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="6" begin="5" end="0" resetval="0xX" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_GPECFG0_REG" acronym="ICSSG_GPECFG0_REG" offset="0x14" width="32" description="GP Enc Configuration 0 Register">
    <bitfield id="RESERVED" width="14" begin="31" end="18" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_CLK_DONE" width="1" begin="17" end="17" resetval="0x0" description="Shift Clock Done is active when PRU0_GPO_SHIFT_CNT is none zero" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_CLK_HIGH" width="1" begin="16" end="16" resetval="0x0" description="Shift Clock Stop High" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_CNT" width="8" begin="15" end="8" resetval="0x0" description="Shift Bit Count" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="7" end="7" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_GP_EN" width="1" begin="6" end="6" resetval="0x0" description="Enable pru&amp;amp;lt;n&amp;amp;gt;r30[15:2] control during shift out mode" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_CLK_FREE" width="1" begin="5" end="5" resetval="0x1" description="Free Running Clock Mode" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPO_SHIFT_SWAP" width="1" begin="4" end="4" resetval="0x0" description="0x0 = No Swap" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="2" begin="3" end="2" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_SHIFT_EN" width="1" begin="1" end="1" resetval="0x1" description="GPI Shift In Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_GPI_SB_P" width="1" begin="0" end="0" resetval="0x1" description="GPI Shift In Start Bit Polarity" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_GPECFG1_REG" acronym="ICSSG_GPECFG1_REG" offset="0x18" width="32" description="GP Enc Configuration 1 Register">
    <bitfield id="RESERVED" width="14" begin="31" end="18" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_CLK_DONE" width="1" begin="17" end="17" resetval="0x0" description="Shift Clock Done is active when PRU1_GPO_SHIFT_CNT is none zero" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_CLK_HIGH" width="1" begin="16" end="16" resetval="0x0" description="Shift Clock Stop High" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_CNT" width="8" begin="15" end="8" resetval="0x0" description="Shift Bit Count" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="7" end="7" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_GP_EN" width="1" begin="6" end="6" resetval="0x0" description="Enable pru&amp;amp;lt;n&amp;amp;gt;r30[15:2] control during shift out mode" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_CLK_FREE" width="1" begin="5" end="5" resetval="0x1" description="Free Running Clock Mode" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPO_SHIFT_SWAP" width="1" begin="4" end="4" resetval="0x0" description="0x0 = No Swap" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="2" begin="3" end="2" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_SHIFT_EN" width="1" begin="1" end="1" resetval="0x1" description="GPI Shift In Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_GPI_SB_P" width="1" begin="0" end="0" resetval="0x1" description="GPI Shift In Start Bit Polarity" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_MII_RT_REG" acronym="ICSSG_MII_RT_REG" offset="0x2C" width="32" description="MII_RT Event Enable Register">
    <bitfield id="RESERVED" width="31" begin="31" end="1" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="MII_RT_EVENT_EN" width="1" begin="0" end="0" resetval="0x1" description="Note: This bit field is non-functional on this device." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_IEPCLK_REG" acronym="ICSSG_IEPCLK_REG" offset="0x30" width="32" description="IEP Configuration Register">
    <bitfield id="RESERVED" width="30" begin="31" end="2" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="IEP1_SLV_EN" width="1" begin="1" end="1" resetval="0x0" description="IEP1 Master Counter Slave enable" range="" rwaccess="RW"/>
    <bitfield id="IEP_OCP_CLK_EN" width="1" begin="0" end="0" resetval="0x0" description="Defines the source of the IEP CLK" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_SPP_REG" acronym="ICSSG_SPP_REG" offset="0x34" width="32" description="Scratchpad Priority and Shift Register">
    <bitfield id="RESERVED" width="28" begin="31" end="4" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="RTU_XFR_SHIFT_EN" width="1" begin="3" end="3" resetval="0x0" description="Shift enable using R0[4:0] to define the number of 32-bit offset for XIN and XOUT operations." range="" rwaccess="RW"/>
    <bitfield id="XFR_BYTE_SHIFT_EN" width="1" begin="2" end="2" resetval="0x0" description="Shift enable using R0[6:0] to define the number of 8-bit offset for XIN and XOUT operations." range="" rwaccess="RW"/>
    <bitfield id="XFR_SHIFT_EN" width="1" begin="1" end="1" resetval="0x0" description="Shift enable using R0[4:0] to define the number of 32-bit offset for XIN and XOUT operations." range="" rwaccess="RW"/>
    <bitfield id="PRU1_PAD_HP_EN" width="1" begin="0" end="0" resetval="0x0" description="Reserved" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_CORE_SYNC_REG" acronym="ICSSG_CORE_SYNC_REG" offset="0x3C" width="32" description="CoreSync Configuration Register">
    <bitfield id="RESERVED" width="31" begin="31" end="1" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="CORE_VBUSP_SYNC_EN" width="1" begin="0" end="0" resetval="0x0" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_SA_MX_REG" acronym="ICSSG_SA_MX_REG" offset="0x40" width="32" description="SA Mux Selection Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM3_REMAP_EN" width="2" begin="11" end="10" resetval="0x0" description="pwm3_remap_en controls icss_wrap glue" range="" rwaccess="RW"/>
    <bitfield id="PWM0_REMAP_EN" width="2" begin="9" end="8" resetval="0x0" description="pwm0_remap_en controls icss_wrap glue" range="" rwaccess="RW"/>
    <bitfield id="SA_MUX_SEL" width="8" begin="7" end="0" resetval="0x0" description="Reserved" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_DIV_REG" acronym="ICSSG_PRU0_SD_CLK_DIV_REG" offset="0x44" width="32" description="SD Register">
    <bitfield id="RESERVED" width="27" begin="31" end="5" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_DIVFACTOR_FRAC" width="1" begin="4" end="4" resetval="0x0" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_DIVFACTOR" width="4" begin="3" end="0" resetval="0x0" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG0" acronym="ICSSG_PRU0_SD_CLK_SEL_REG0" offset="0x48" width="32" description="PRU0 FD, ACC and Clock Selection Register 0">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_0" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_0" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_0" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_0" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL0" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV0" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL0" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG0" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG0" offset="0x4C" width="32" description="PRU0 FD and Over Sample Size Register 0">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_0" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_0" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_0" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_0" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_0" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_0" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE0" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG1" acronym="ICSSG_PRU0_SD_CLK_SEL_REG1" offset="0x50" width="32" description="PRU0 FD, ACC and Clock Selection Register 1">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_1" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_1" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_1" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_1" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL1" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV1" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL1" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG1" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG1" offset="0x54" width="32" description="PRU0 FD and Over Sample Size Register 1">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_1" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_1" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_1" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_1" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_1" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_1" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE1" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG2" acronym="ICSSG_PRU0_SD_CLK_SEL_REG2" offset="0x58" width="32" description="PRU0 FD, ACC and Clock Selection Register 2">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_2" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_2" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_2" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_2" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL2" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV2" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL2" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG2" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG2" offset="0x5C" width="32" description="PRU0 FD and Over Sample Size Register 2">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_2" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_2" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_2" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_2" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_2" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_2" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE2" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG3" acronym="ICSSG_PRU0_SD_CLK_SEL_REG3" offset="0x60" width="32" description="PRU0 FD, ACC and Clock Selection Register 3">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_3" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_3" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_3" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_3" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL3" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV3" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL3" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG3" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG3" offset="0x64" width="32" description="PRU0 FD and Over Sample Size Register 3">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_3" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_3" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_3" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_3" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_3" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_3" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE3" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG4" acronym="ICSSG_PRU0_SD_CLK_SEL_REG4" offset="0x68" width="32" description="PRU0 FD, ACC and Clock Selection Register 4">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_4" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_4" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_4" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_4" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL4" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV4" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL4" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG4" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG4" offset="0x6C" width="32" description="PRU0 FD and Over Sample Size Register 4">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_4" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_4" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_4" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_4" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_4" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_4" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE4" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG5" acronym="ICSSG_PRU0_SD_CLK_SEL_REG5" offset="0x70" width="32" description="PRU0 FD, ACC and Clock Selection Register 5">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_5" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_5" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_5" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_5" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL5" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV5" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL5" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG5" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG5" offset="0x74" width="32" description="PRU0 FD and Over Sample Size Register 5">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_5" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_5" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_5" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_5" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_5" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_5" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE5" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG6" acronym="ICSSG_PRU0_SD_CLK_SEL_REG6" offset="0x78" width="32" description="PRU0 FD, ACC and Clock Selection Register 6">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_6" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_6" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_6" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_6" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL6" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV6" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL6" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG6" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG6" offset="0x7C" width="32" description="PRU0 FD and Over Sample Size Register 6">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_6" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_6" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_6" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_6" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_6" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_6" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE6" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG7" acronym="ICSSG_PRU0_SD_CLK_SEL_REG7" offset="0x80" width="32" description="PRU0 FD, ACC and Clock Selection Register 7">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_7" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_7" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_7" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_7" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL7" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV7" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL7" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG7" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG7" offset="0x84" width="32" description="PRU0 FD and Over Sample Size Register 7">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_7" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_7" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_7" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_7" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_7" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_7" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE7" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_CLK_SEL_REG8" acronym="ICSSG_PRU0_SD_CLK_SEL_REG8" offset="0x88" width="32" description="PRU0 FD, ACC and Clock Selection Register 8">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_8" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MAX_LIMIT_8" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_8" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ZERO_MIN_LIMIT_8" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_ACC_SEL8" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_INV8" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_CLK_SEL8" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_SD_SAMPLE_SIZE_REG8" acronym="ICSSG_PRU0_SD_SAMPLE_SIZE_REG8" offset="0x8C" width="32" description="PRU0 FD and Over Sample Size Register 8">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_EN_8" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_8" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MAX_LIMIT_8" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_8" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_ONE_MIN_LIMIT_8" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU0_FD_WINDOW_SIZE_8" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_SD_SAMPLE_SIZE8" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_DIV_REG" acronym="ICSSG_PRU1_SD_CLK_DIV_REG" offset="0x90" width="32" description="SD Register">
    <bitfield id="RESERVED" width="27" begin="31" end="5" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_DIVFACTOR_FRAC" width="1" begin="4" end="4" resetval="0x0" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_DIVFACTOR" width="4" begin="3" end="0" resetval="0x0" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG0" acronym="ICSSG_PRU1_SD_CLK_SEL_REG0" offset="0x94" width="32" description="PRU1 FD, ACC and Clock Selection Register 0">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_0" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_0" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_0" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_0" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL0" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV0" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL0" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG0" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG0" offset="0x98" width="32" description="PRU1 FD and Over Sample Size Register 0">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_0" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_0" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_0" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_0" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_0" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_0" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE0" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG1" acronym="ICSSG_PRU1_SD_CLK_SEL_REG1" offset="0x9C" width="32" description="PRU1 FD, ACC and Clock Selection Register 1">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_1" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_1" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_1" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_1" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL1" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV1" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL1" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG1" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG1" offset="0xA0" width="32" description="PRU1 FD and Over Sample Size Register 1">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_1" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_1" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_1" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_1" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_1" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_1" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE1" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG2" acronym="ICSSG_PRU1_SD_CLK_SEL_REG2" offset="0xA4" width="32" description="PRU1 FD, ACC and Clock Selection Register 2">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_2" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_2" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_2" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_2" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL2" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV2" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL2" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG2" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG2" offset="0xA8" width="32" description="PRU1 FD and Over Sample Size Register 2">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_2" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_2" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_2" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_2" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_2" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_2" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE2" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG3" acronym="ICSSG_PRU1_SD_CLK_SEL_REG3" offset="0xAC" width="32" description="PRU1 FD, ACC and Clock Selection Register 3">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_3" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_3" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_3" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_3" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL3" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV3" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL3" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG3" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG3" offset="0xB0" width="32" description="PRU1 FD and Over Sample Size Register 3">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_3" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_3" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_3" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_3" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_3" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_3" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE3" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG4" acronym="ICSSG_PRU1_SD_CLK_SEL_REG4" offset="0xB4" width="32" description="PRU1 FD, ACC and Clock Selection Register 4">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_4" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_4" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_4" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_4" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL4" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV4" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL4" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG4" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG4" offset="0xB8" width="32" description="PRU1 FD and Over Sample Size Register 4">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_4" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_4" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_4" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_4" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_4" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_4" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE4" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG5" acronym="ICSSG_PRU1_SD_CLK_SEL_REG5" offset="0xBC" width="32" description="PRU1 FD, ACC and Clock Selection Register 5">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_5" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_5" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_5" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_5" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL5" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV5" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL5" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG5" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG5" offset="0xC0" width="32" description="PRU1 FD and Over Sample Size Register 5">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_5" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_5" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_5" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_5" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_5" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_5" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE5" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG6" acronym="ICSSG_PRU1_SD_CLK_SEL_REG6" offset="0xC4" width="32" description="PRU1 FD, ACC and Clock Selection Register 6">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_6" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_6" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_6" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_6" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL6" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV6" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL6" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG6" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG6" offset="0xC8" width="32" description="PRU1 FD and Over Sample Size Register 6">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_6" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_6" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_6" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_6" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_6" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_6" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE6" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG7" acronym="ICSSG_PRU1_SD_CLK_SEL_REG7" offset="0xCC" width="32" description="PRU1 FD, ACC and Clock Selection Register 7">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_7" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_7" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_7" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_7" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL7" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV7" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL7" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG7" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG7" offset="0xD0" width="32" description="PRU1 FD and Over Sample Size Register 7">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_7" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_7" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_7" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_7" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_7" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_7" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE7" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_CLK_SEL_REG8" acronym="ICSSG_PRU1_SD_CLK_SEL_REG8" offset="0xD4" width="32" description="PRU1 FD, ACC and Clock Selection Register 8">
    <bitfield id="RESERVED" width="9" begin="31" end="23" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_8" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect Zero Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MAX_LIMIT_8" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect Zero Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_8" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect Zero Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ZERO_MIN_LIMIT_8" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect Zero Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="5" begin="10" end="6" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_ACC_SEL8" width="2" begin="5" end="4" resetval="0x0" description="00: acc3 is selected" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="1" begin="3" end="3" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_INV8" width="1" begin="2" end="2" resetval="0x0" description="Optional clock inversion post clock selection mux" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_CLK_SEL8" width="2" begin="1" end="0" resetval="0x0" description="Selects the clock source" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_SD_SAMPLE_SIZE_REG8" acronym="ICSSG_PRU1_SD_SAMPLE_SIZE_REG8" offset="0xD8" width="32" description="PRU1 FD and Over Sample Size Register 8">
    <bitfield id="RESERVED" width="8" begin="31" end="24" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_EN_8" width="1" begin="23" end="23" resetval="0x0" description="Fast Detect One Enable" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_8" width="1" begin="22" end="22" resetval="0x0" description="Fast Detect One Count Max Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MAX_LIMIT_8" width="5" begin="21" end="17" resetval="0x0" description="Fast Detect One Count Max Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_8" width="1" begin="16" end="16" resetval="0x0" description="Fast Detect One Count Min Threshold Hit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_ONE_MIN_LIMIT_8" width="5" begin="15" end="11" resetval="0x0" description="Fast Detect One Count Min Threshold" range="" rwaccess="RW"/>
    <bitfield id="PRU1_FD_WINDOW_SIZE_8" width="3" begin="10" end="8" resetval="0x0" description="Fast Detect Window Size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_SD_SAMPLE_SIZE8" width="8" begin="7" end="0" resetval="0x0" description="Over Sample Rate" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_RX_CFG_REG" acronym="ICSSG_PRU0_ED_RX_CFG_REG" offset="0xE0" width="32" description="PRU0 ED Receive Global Configuration Register">
    <bitfield id="PRU0_ED_RX_DIV_FACTOR" width="16" begin="31" end="16" resetval="0x0" description="div factor for divh16" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_DIV_FACTOR_FRAC" width="1" begin="15" end="15" resetval="0x0" description="Enable Fractional division before the divh16" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="10" begin="14" end="5" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_CLK_SEL" width="1" begin="4" end="4" resetval="0x0" description="Selects the clock source for the divh16fr" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_SB_POL" width="1" begin="3" end="3" resetval="0x1" description="Defines the polarity of the RX Start Bit" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_SAMPLE_SIZE" width="3" begin="2" end="0" resetval="0x7" description="Over Sample size" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_TX_CFG_REG" acronym="ICSSG_PRU0_ED_TX_CFG_REG" offset="0xE4" width="32" description="PRU0 ED Transmit Global Configuration Register">
    <bitfield id="PRU0_ED_TX_DIV_FACTOR" width="16" begin="31" end="16" resetval="0x0" description="div factor for divh16" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_DIV_FACTOR_FRAC" width="1" begin="15" end="15" resetval="0x0" description="Enable Fractional division before the divh16" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="4" begin="14" end="11" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ENDAT2_CLK_SYNC" width="1" begin="10" end="10" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat2_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ENDAT1_CLK_SYNC" width="1" begin="9" end="9" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat1_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ENDAT0_CLK_SYNC" width="1" begin="8" end="8" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat0_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_BUSY_2" width="1" begin="7" end="7" resetval="0x0" description="Determines when you can assert tx go for channel 2" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_BUSY_1" width="1" begin="6" end="6" resetval="0x0" description="Determines when you can assert tx go for channel 1" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_BUSY_0" width="1" begin="5" end="5" resetval="0x0" description="Determines when you can assert tx go for channel 0" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_TX_CLK_SEL" width="1" begin="4" end="4" resetval="0x0" description="Selects the clock source for the divh16fr" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="4" begin="3" end="0" resetval="0xX" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH0_CFG0_REG" acronym="ICSSG_PRU0_ED_CH0_CFG0_REG" offset="0xE8" width="32" description="PRU0 ED Channel 0 Configuration 0 Register">
    <bitfield id="PRU0_ED_TX_FIFO_SWAP_BITS0" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_SW_CLK_OUT0" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_CLK_OUT_OVR_EN0" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_SNOOP0" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_RX_FRAME_SIZE0" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_FRAME_SIZE0" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_WDLY0" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH0_CFG1_REG" acronym="ICSSG_PRU0_ED_CH0_CFG1_REG" offset="0xEC" width="32" description="PRU0 ED Channel 0 Configuration 1 Register">
    <bitfield id="PRU0_ED_RX_EN_COUNTER0" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TST_DELAY_COUNTER0" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH1_CFG0_REG" acronym="ICSSG_PRU0_ED_CH1_CFG0_REG" offset="0xF0" width="32" description="PRU0 ED Channel 1 Configuration 0 Register">
    <bitfield id="PRU0_ED_TX_FIFO_SWAP_BITS1" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_SW_CLK_OUT1" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_CLK_OUT_OVR_EN1" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_SNOOP1" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_RX_FRAME_SIZE1" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_FRAME_SIZE1" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_WDLY1" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH1_CFG1_REG" acronym="ICSSG_PRU0_ED_CH1_CFG1_REG" offset="0xF4" width="32" description="PRU0 ED Channel 1 Configuration 1 Register">
    <bitfield id="PRU0_ED_RX_EN_COUNTER1" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TST_DELAY_COUNTER1" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH2_CFG0_REG" acronym="ICSSG_PRU0_ED_CH2_CFG0_REG" offset="0xF8" width="32" description="PRU0 ED Channel 2 Configuration 0 Register">
    <bitfield id="PRU0_ED_TX_FIFO_SWAP_BITS2" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_SW_CLK_OUT2" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_CLK_OUT_OVR_EN2" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_RX_SNOOP2" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU0_ED_RX_FRAME_SIZE2" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_FRAME_SIZE2" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TX_WDLY2" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU0_ED_CH2_CFG1_REG" acronym="ICSSG_PRU0_ED_CH2_CFG1_REG" offset="0xFC" width="32" description="PRU0 ED Channel 2 Configuration 1 Register">
    <bitfield id="PRU0_ED_RX_EN_COUNTER2" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU0_ED_TST_DELAY_COUNTER2" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_RX_CFG_REG" acronym="ICSSG_PRU1_ED_RX_CFG_REG" offset="0x100" width="32" description="PRU1 ED Receive Global Configuration Register">
    <bitfield id="PRU1_ED_RX_DIV_FACTOR" width="16" begin="31" end="16" resetval="0x0" description="div factor for divh16" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_DIV_FACTOR_FRAC" width="1" begin="15" end="15" resetval="0x0" description="Enable Fractional division before the divh16" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="10" begin="14" end="5" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_CLK_SEL" width="1" begin="4" end="4" resetval="0x0" description="Selects the clock source for the divh16fr" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_SB_POL" width="1" begin="3" end="3" resetval="0x1" description="Defines the polarity of the RX Start Bit" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_SAMPLE_SIZE" width="3" begin="2" end="0" resetval="0x7" description="Over Sample size" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_TX_CFG_REG" acronym="ICSSG_PRU1_ED_TX_CFG_REG" offset="0x104" width="32" description="PRU1 ED Transmit Global Configuration Register">
    <bitfield id="PRU1_ED_TX_DIV_FACTOR" width="16" begin="31" end="16" resetval="0x0" description="div factor for divh16" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_DIV_FACTOR_FRAC" width="1" begin="15" end="15" resetval="0x0" description="Enable Fractional division before the divh16" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="4" begin="14" end="11" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ENDAT2_CLK_SYNC" width="1" begin="10" end="10" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat2_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ENDAT1_CLK_SYNC" width="1" begin="9" end="9" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat1_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ENDAT0_CLK_SYNC" width="1" begin="8" end="8" resetval="0x1" description="Observation of pru&amp;amp;lt;n&amp;amp;gt;_endat0_clk pin state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_BUSY_2" width="1" begin="7" end="7" resetval="0x0" description="Determines when you can assert tx go for channel 2" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_BUSY_1" width="1" begin="6" end="6" resetval="0x0" description="Determines when you can assert tx go for channel 1" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_BUSY_0" width="1" begin="5" end="5" resetval="0x0" description="Determines when you can assert tx go for channel 0" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_TX_CLK_SEL" width="1" begin="4" end="4" resetval="0x0" description="Selects the clock source for the divh16fr" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="4" begin="3" end="0" resetval="0xX" description="" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH0_CFG0_REG" acronym="ICSSG_PRU1_ED_CH0_CFG0_REG" offset="0x108" width="32" description="PRU1 ED Channel 0 Configuration 0 Register">
    <bitfield id="PRU1_ED_TX_FIFO_SWAP_BITS0" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_SW_CLK_OUT0" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_CLK_OUT_OVR_EN0" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_SNOOP0" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_RX_FRAME_SIZE0" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_FRAME_SIZE0" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_WDLY0" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH0_CFG1_REG" acronym="ICSSG_PRU1_ED_CH0_CFG1_REG" offset="0x10C" width="32" description="PRU1 ED Channel 0 Configuration 1 Register">
    <bitfield id="PRU1_ED_RX_EN_COUNTER0" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TST_DELAY_COUNTER0" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH1_CFG0_REG" acronym="ICSSG_PRU1_ED_CH1_CFG0_REG" offset="0x110" width="32" description="PRU1 ED Channel 1 Configuration 0 Register">
    <bitfield id="PRU1_ED_TX_FIFO_SWAP_BITS1" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_SW_CLK_OUT1" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_CLK_OUT_OVR_EN1" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_SNOOP1" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_RX_FRAME_SIZE1" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_FRAME_SIZE1" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_WDLY1" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH1_CFG1_REG" acronym="ICSSG_PRU1_ED_CH1_CFG1_REG" offset="0x114" width="32" description="PRU1 ED Channel 1 Configuration 1 Register">
    <bitfield id="PRU1_ED_RX_EN_COUNTER1" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TST_DELAY_COUNTER1" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH2_CFG0_REG" acronym="ICSSG_PRU1_ED_CH2_CFG0_REG" offset="0x118" width="32" description="PRU1 ED Channel 2 Configuration 0 Register">
    <bitfield id="PRU1_ED_TX_FIFO_SWAP_BITS2" width="1" begin="31" end="31" resetval="0x0" description="This enables the swapping of the bits when they are loaded into the TX FIFO." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_SW_CLK_OUT2" width="1" begin="30" end="30" resetval="0x0" description="This controls the state of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk when endat_clk_out_override_en is set" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_CLK_OUT_OVR_EN2" width="1" begin="29" end="29" resetval="0x0" description="When set, this gives the SW the ablity to have direct control of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_clk. CAREFUL consideration to not override clock during free running mode of this will cause clock duty cycle violation." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_RX_SNOOP2" width="1" begin="28" end="28" resetval="0x0" description="Direct Read of pru&amp;amp;lt;n&amp;amp;gt;_ endat&amp;amp;lt;m&amp;amp;gt;_in state" range="" rwaccess="R"/>
    <bitfield id="PRU1_ED_RX_FRAME_SIZE2" width="12" begin="27" end="16" resetval="0x0" description="RX frame size, after SB is detected" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_FRAME_SIZE2" width="5" begin="15" end="11" resetval="0x0" description="TX frame size" range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TX_WDLY2" width="11" begin="10" end="0" resetval="0x0" description="EnDAT TX wire delay using 200Mhz steps (CORE clock). Software should program a number divisible by 5. (Hw" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PRU1_ED_CH2_CFG1_REG" acronym="ICSSG_PRU1_ED_CH2_CFG1_REG" offset="0x11C" width="32" description="PRU1 ED Channel 2 Configuration 1 Register">
    <bitfield id="PRU1_ED_RX_EN_COUNTER2" width="16" begin="31" end="16" resetval="0x0" description="This counter will start counting after the last TX bit is sent and when it expires the HW will automatically arm the receiver (rx_en = 1)." range="" rwaccess="RW"/>
    <bitfield id="PRU1_ED_TST_DELAY_COUNTER2" width="16" begin="15" end="0" resetval="0x0" description="This counter will start after the tx_wire_delay has been met. After this counter expires the 1st transmit clock will be driven high. Counts in CORE cycles. Software programs value divisible by 5, and hardware will count by 5." range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_RTU0_POKE_EN0_REG" acronym="ICSSG_RTU0_POKE_EN0_REG" offset="0x124" width="32" description="RTU0 Poke Enable 0 Register">
    <bitfield id="RTU0_POKE_R27_EN" width="4" begin="31" end="28" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R26_EN" width="4" begin="27" end="24" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R25_EN" width="4" begin="23" end="20" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R24_EN" width="4" begin="19" end="16" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R23_EN" width="4" begin="15" end="12" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R22_EN" width="4" begin="11" end="8" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R21_EN" width="4" begin="7" end="4" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU0_POKE_R20_EN" width="4" begin="3" end="0" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_RTU1_POKE_EN0_REG" acronym="ICSSG_RTU1_POKE_EN0_REG" offset="0x12C" width="32" description="RTU1 Poke Enable 0 Register">
    <bitfield id="RTU1_POKE_R27_EN" width="4" begin="31" end="28" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R26_EN" width="4" begin="27" end="24" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R25_EN" width="4" begin="23" end="20" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R24_EN" width="4" begin="19" end="16" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R23_EN" width="4" begin="15" end="12" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R22_EN" width="4" begin="11" end="8" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R21_EN" width="4" begin="7" end="4" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
    <bitfield id="RTU1_POKE_R20_EN" width="4" begin="3" end="0" resetval="0x0" description="This enables the external values to get poked into PRU&#8217;s internal register" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM0" acronym="ICSSG_PWM0" offset="0x130" width="32" description="PWM0 Trip Configuration Register">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM0_TRIP_S" width="1" begin="30" end="30" resetval="0x0" description="Trip Status" range="" rwaccess="RW"/>
    <bitfield id="PWM0_TRIP_VEC" width="9" begin="29" end="21" resetval="0x0" description="Trip trigger cause vector" range="" rwaccess="R"/>
    <bitfield id="PWM0_POS_ERR_TRIP" width="1" begin="20" end="20" resetval="0x0" description="Software position feedback error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM0_OVER_ERR_TRIP" width="1" begin="19" end="19" resetval="0x0" description="Software overcurrent error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM0_TRIP_RESET" width="1" begin="18" end="18" resetval="0x0" description="Software trip reset" range="" rwaccess="RW"/>
    <bitfield id="PWM0_TRIP_CMP0_EN" width="1" begin="17" end="17" resetval="0x0" description="CMP0 reset trip clear enable" range="" rwaccess="RW"/>
    <bitfield id="PWM0_TRIP_MASK" width="9" begin="16" end="8" resetval="0x0" description="Software mask for trip, one hot" range="" rwaccess="RW"/>
    <bitfield id="PWM0_DEBOUNCE_VALUE" width="8" begin="7" end="0" resetval="0x0" description="Debounce counter , defines the number of core_clk required for the pulse not to get rejected" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM1" acronym="ICSSG_PWM1" offset="0x134" width="32" description="PWM1 Trip Configuration Register">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM1_TRIP_S" width="1" begin="30" end="30" resetval="0x0" description="Trip status" range="" rwaccess="RW"/>
    <bitfield id="PWM1_TRIP_VEC" width="9" begin="29" end="21" resetval="0x0" description="Trip trigger cause vector" range="" rwaccess="R"/>
    <bitfield id="PWM1_POS_ERR_TRIP" width="1" begin="20" end="20" resetval="0x0" description="Software position feedback error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM1_OVER_ERR_TRIP" width="1" begin="19" end="19" resetval="0x0" description="Software overcurrent error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM1_TRIP_RESET" width="1" begin="18" end="18" resetval="0x0" description="Software trip reset" range="" rwaccess="RW"/>
    <bitfield id="PWM1_TRIP_CMP0_EN" width="1" begin="17" end="17" resetval="0x0" description="CMP0 reset trip clear enable" range="" rwaccess="RW"/>
    <bitfield id="PWM1_TRIP_MASK" width="9" begin="16" end="8" resetval="0x0" description="Software mask for trip, one hot" range="" rwaccess="RW"/>
    <bitfield id="PWM1_DEBOUNCE_VALUE" width="8" begin="7" end="0" resetval="0x0" description="Debounce counter, defines the number of core_clk required for the pulse not to get rejected" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM2" acronym="ICSSG_PWM2" offset="0x138" width="32" description="PWM2 Trip Configuration Register">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM2_TRIP_S" width="1" begin="30" end="30" resetval="0x0" description="Trip status" range="" rwaccess="RW"/>
    <bitfield id="PWM2_TRIP_VEC" width="9" begin="29" end="21" resetval="0x0" description="Trip trigger cause vector" range="" rwaccess="R"/>
    <bitfield id="PWM2_POS_ERR_TRIP" width="1" begin="20" end="20" resetval="0x0" description="Software position feedback error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM2_OVER_ERR_TRIP" width="1" begin="19" end="19" resetval="0x0" description="Software overcurrent error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM2_TRIP_RESET" width="1" begin="18" end="18" resetval="0x0" description="Software trip reset" range="" rwaccess="RW"/>
    <bitfield id="PWM2_TRIP_CMP0_EN" width="1" begin="17" end="17" resetval="0x0" description="CMP0 reset trip clear enable" range="" rwaccess="RW"/>
    <bitfield id="PWM2_TRIP_MASK" width="9" begin="16" end="8" resetval="0x0" description="Software mask for trip, one hot" range="" rwaccess="RW"/>
    <bitfield id="PWM2_DEBOUNCE_VALUE" width="8" begin="7" end="0" resetval="0x0" description="Debounce counter, defines the number of core_clk required for the pulse not to get rejected" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM3" acronym="ICSSG_PWM3" offset="0x13C" width="32" description="PWM3 Trip Configuration Register">
    <bitfield id="RESERVED" width="1" begin="31" end="31" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM3_TRIP_S" width="1" begin="30" end="30" resetval="0x0" description="Trip status" range="" rwaccess="RW"/>
    <bitfield id="PWM3_TRIP_VEC" width="9" begin="29" end="21" resetval="0x0" description="Trip trigger cause vector" range="" rwaccess="R"/>
    <bitfield id="PWM3_POS_ERR_TRIP" width="1" begin="20" end="20" resetval="0x0" description="Software position feedback error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM3_OVER_ERR_TRIP" width="1" begin="19" end="19" resetval="0x0" description="Software overcurrent error trip" range="" rwaccess="RW"/>
    <bitfield id="PWM3_TRIP_RESET" width="1" begin="18" end="18" resetval="0x0" description="Software trip reset" range="" rwaccess="RW"/>
    <bitfield id="PWM3_TRIP_CMP0_EN" width="1" begin="17" end="17" resetval="0x0" description="CMP0 reset trip clear enable" range="" rwaccess="RW"/>
    <bitfield id="PWM3_TRIP_MASK" width="9" begin="16" end="8" resetval="0x0" description="Software mask for trip, one hot" range="" rwaccess="RW"/>
    <bitfield id="PWM3_DEBOUNCE_VALUE" width="8" begin="7" end="0" resetval="0x0" description="Debounce counter, defines the number of core_clk required for the pulse not to get rejected" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM0_0" acronym="ICSSG_PWM0_0" offset="0x140" width="32" description="PWM0 State Configuration 0 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_0_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM0_1" acronym="ICSSG_PWM0_1" offset="0x144" width="32" description="PWM0 State Configuration 1 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_1_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM0_2" acronym="ICSSG_PWM0_2" offset="0x148" width="32" description="PWM0 State Configuration 2 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM0_2_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM1_0" acronym="ICSSG_PWM1_0" offset="0x14C" width="32" description="PWM1 State Configuration 0 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_0_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM1_1" acronym="ICSSG_PWM1_1" offset="0x150" width="32" description="PWM1 State Configuration 1 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_1_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM1_2" acronym="ICSSG_PWM1_2" offset="0x154" width="32" description="PWM1 State Configuration 2 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM1_2_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM2_0" acronym="ICSSG_PWM2_0" offset="0x158" width="32" description="PWM2 State Configuration 0 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_0_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM2_1" acronym="ICSSG_PWM2_1" offset="0x15C" width="32" description="PWM2 State Configuration 1 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_1_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM2_2" acronym="ICSSG_PWM2_2" offset="0x160" width="32" description="PWM2 State Configuration 2 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM2_2_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM3_0" acronym="ICSSG_PWM3_0" offset="0x164" width="32" description="PWM3 State Configuration 0 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_0_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM3_1" acronym="ICSSG_PWM3_1" offset="0x168" width="32" description="PWM3 State Configuration 1 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_1_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PWM3_2" acronym="ICSSG_PWM3_2" offset="0x16C" width="32" description="PWM3 State Configuration 2 Register">
    <bitfield id="RESERVED" width="20" begin="31" end="12" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_NEG_ACT" width="2" begin="11" end="10" resetval="0x0" description="Active neg state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_POS_ACT" width="2" begin="9" end="8" resetval="0x0" description="Active pos state 00 toggle 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_NEG_TRIP" width="2" begin="7" end="6" resetval="0x0" description="Trip neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_POS_TRIP" width="2" begin="5" end="4" resetval="0x0" description="Trip pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_NEG_INIT" width="2" begin="3" end="2" resetval="0x0" description="Initial neg state 00 z 01 L 10 H" range="" rwaccess="RW"/>
    <bitfield id="PWM3_2_POS_INIT" width="2" begin="1" end="0" resetval="0x0" description="Initial pos state 00 z 01 L 10 H" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_SPIN_LOCK0" acronym="ICSSG_SPIN_LOCK0" offset="0x170" width="32" description="Spin Lock 0 Register">
    <bitfield id="RESERVED" width="18" begin="31" end="14" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="MMR_OWN_REQ_VECTOR_0" width="6" begin="13" end="8" resetval="0x0" description="Spin Lock flag Vector" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="6" begin="7" end="2" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="MMR_OWN_REQ_CLR_0" width="1" begin="1" end="1" resetval="0x0" description="Spin Lock Status Clear" range="" rwaccess="W"/>
    <bitfield id="MMR_OWN_REQ_STATUS_0" width="1" begin="0" end="0" resetval="0xX" description="Spin Lock Status" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_SPIN_LOCK1" acronym="ICSSG_SPIN_LOCK1" offset="0x174" width="32" description="Spin Lock 1 Register">
    <bitfield id="RESERVED" width="18" begin="31" end="14" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="MMR_OWN_REQ_VECTOR_1" width="6" begin="13" end="8" resetval="0x0" description="Spin Lock flag Vector" range="" rwaccess="RW"/>
    <bitfield id="RESERVED" width="6" begin="7" end="2" resetval="0xX" description="" range="" rwaccess="RW"/>
    <bitfield id="MMR_OWN_REQ_CLR_1" width="1" begin="1" end="1" resetval="0x0" description="Spin Lock Status Clear" range="" rwaccess="W"/>
    <bitfield id="MMR_OWN_REQ_STATUS_1" width="1" begin="0" end="0" resetval="0xX" description="Spin Lock Status" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_CFG0" acronym="ICSSG_PA_STAT_PDSP_CFG0" offset="0x178" width="32" description="PA STATS PDSP0 Vector 0 Register">
    <bitfield id="PA_PDSP0_INC_TYPE" width="1" begin="31" end="31" resetval="0x0" description="pa_pdsp${i}_inc_type" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP0_INC_VAL" width="17" begin="30" end="14" resetval="0x0" description="pa_pdsp${i}_inc_val" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP0_INDEX" width="14" begin="13" end="0" resetval="0x0" description="pa_pdsp${i}_index" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_STAT0" acronym="ICSSG_PA_STAT_PDSP_STAT0" offset="0x17C" width="32" description="PA STATS PDSP0 Status 0 Register">
    <bitfield id="RESERVED" width="28" begin="31" end="4" resetval="0xX" description="" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP0_STATUS" width="3" begin="3" end="1" resetval="0x0" description="pa_pdsp${i}_status" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP0_READY" width="1" begin="0" end="0" resetval="0x0" description="pa_pdsp${i}_ready" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_CFG1" acronym="ICSSG_PA_STAT_PDSP_CFG1" offset="0x180" width="32" description="PA STATS PDSP0 Vector 1 Register">
    <bitfield id="PA_PDSP1_INC_TYPE" width="1" begin="31" end="31" resetval="0x0" description="pa_pdsp${i}_inc_type" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP1_INC_VAL" width="17" begin="30" end="14" resetval="0x0" description="pa_pdsp${i}_inc_val" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP1_INDEX" width="14" begin="13" end="0" resetval="0x0" description="pa_pdsp${i}_index" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_STAT1" acronym="ICSSG_PA_STAT_PDSP_STAT1" offset="0x184" width="32" description="PA STATS PDSP0 Status 1 Register">
    <bitfield id="RESERVED" width="28" begin="31" end="4" resetval="0xX" description="" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP1_STATUS" width="3" begin="3" end="1" resetval="0x0" description="pa_pdsp${i}_status" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP1_READY" width="1" begin="0" end="0" resetval="0x0" description="pa_pdsp${i}_ready" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_CFG2" acronym="ICSSG_PA_STAT_PDSP_CFG2" offset="0x188" width="32" description="PA STATS PDSP0 Vector 2 Register">
    <bitfield id="PA_PDSP2_INC_TYPE" width="1" begin="31" end="31" resetval="0x0" description="pa_pdsp${i}_inc_type" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP2_INC_VAL" width="17" begin="30" end="14" resetval="0x0" description="pa_pdsp${i}_inc_val" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP2_INDEX" width="14" begin="13" end="0" resetval="0x0" description="pa_pdsp${i}_index" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_STAT2" acronym="ICSSG_PA_STAT_PDSP_STAT2" offset="0x18C" width="32" description="PA STATS PDSP0 Status 2 Register">
    <bitfield id="RESERVED" width="28" begin="31" end="4" resetval="0xX" description="" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP2_STATUS" width="3" begin="3" end="1" resetval="0x0" description="pa_pdsp${i}_status" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP2_READY" width="1" begin="0" end="0" resetval="0x0" description="pa_pdsp${i}_ready" range="" rwaccess="R"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_CFG3" acronym="ICSSG_PA_STAT_PDSP_CFG3" offset="0x190" width="32" description="PA STATS PDSP0 Vector 3 Register">
    <bitfield id="PA_PDSP3_INC_TYPE" width="1" begin="31" end="31" resetval="0x0" description="pa_pdsp${i}_inc_type" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP3_INC_VAL" width="17" begin="30" end="14" resetval="0x0" description="pa_pdsp${i}_inc_val" range="" rwaccess="RW"/>
    <bitfield id="PA_PDSP3_INDEX" width="14" begin="13" end="0" resetval="0x0" description="pa_pdsp${i}_index" range="" rwaccess="RW"/>
  </register>
  <register id="ICSSG_PA_STAT_PDSP_STAT3" acronym="ICSSG_PA_STAT_PDSP_STAT3" offset="0x194" width="32" description="PA STATS PDSP0 Status 3 Register">
    <bitfield id="RESERVED" width="28" begin="31" end="4" resetval="0xX" description="" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP3_STATUS" width="3" begin="3" end="1" resetval="0x0" description="pa_pdsp${i}_status" range="" rwaccess="R"/>
    <bitfield id="PA_PDSP3_READY" width="1" begin="0" end="0" resetval="0x0" description="pa_pdsp${i}_ready" range="" rwaccess="R"/>
  </register>
</module>
